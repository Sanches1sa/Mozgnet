/* ============================================================================
 * uno_q_brain.ino — ЦЕНТРАЛЬНЫЙ ХАБ «ИСКУССТВЕННЫЙ МОЗГ-12»
 * Плата: Arduino UNO Q (микроконтроллерная часть, STM32U585 / Zephyr)
 * Версия: v2.88 — камера с нейросетью (sketch/esp32cam_tflite): приём
 *   зрения (тип 0x03) и голосов (0x04) камеры, RPC cam_vis / cam_vote /
 *   cam_vote_res / cam_say; кадр принимается в отдельный буфер (статус и
 *   зрение больше не портят последний JPEG).
 * v2.85 — меньше лепета: 92% слов из словаря, 5% исследования
 * буквами, фильтр «похоже на слово» отсекает «ИЧИИЕИФИИЪ» перед выдачей
 * нейронам. v2.5-app: обмен с Linux через
 * Arduino_RouterBridge (MessagePack-RPC: notify-события + provide-методы);
 * v2.5: значение буфера нейросети (номер буквы) выведено на D6 (PWM).
 * v2.19: ФРАЗЫ МОЗГА — НА D6: Python шлёт номера букв фразы (RPC d6seq),
 *       скетч проигрывает их PWM-импульсами на D6; буквы/слова больше НЕ
 *       печатаются в Serial и не показываются человеку (только фразы).
 * v2.22: БУФЕР СЛОВ НА D6 (вместо номера буквы): на пин уходят БАЙТЫ
 *       текстового буфера, в котором слова (UTF-8): своё готовое слово —
 *       из wordCommit, фраза мозга — RPC d6seq декодируется в текст
 *       (RU33 + пробелы). Номера букв на D6 больше не выходят.
 * v2.23: НЕЙРОНЫ СНОВА ОТВЕЧАЮТ (было: «работают только два»):
 *       шина I2C замедлена до 20 кГц (длинные провода до нейронов),
 *       добавлено восстановление зависшей шины (9 тактов SCL + STOP —
 *       по спецификации, при старте и когда молчат ВСЕ нейроны),
 *       ретрай пустого опроса и живость, устойчивая к одиночным сбоям
 *       (alive сбрасывается только после 3 пустых опросов подряд).
 * v2.24: МОСТ БОЛЬШЕ НЕ ПАДАЕТ НА UTF-8 (ошибки «'utf-8' codec can't
 *       decode byte 0xae/0xff/0x93/0xd0 ...» в Bridge.read_loop):
 *       слова нейронов приходят с шумящей шины I2C СЫРЫМИ байтами —
 *       обрыв посреди двухбайтовой буквы (0xD0 без продолжения) или
 *       случайный байт (0xFF/0xAE) ломали UTF-8 в строках on_msg/
 *       on_state, и Python терял события целиком. Теперь: utf8Fix()
 *       чинит все строки перед мостом, пакеты нейронов жёстко
 *       проверяются (мусор не попадает в мозг), счётчик шума busBad
 *       виден в [NET], а всплеск шума чинит шину (9 тактов SCL),
 *       стимулы/буфер режутся только по границе буквы UTF-8.
 * v2.26: МЫСЛИ — СЛОВАМИ ИЗ СЛОВАРЯ (на самой плате): буквогенератор
 *       больше не лепечет буквами вслепую — при старте слова сеть
 *       выбирает ЦЕЛОЕ СЛОВО из встроенного словаря (64 частых слова),
 *       буквы слова идут обычным конвейером (частотный тег нейронам,
 *       STIM/D6/мелодия D8, SAY=). У каждого слова свой вес + контекст
 *       (текст/звук/спайки) в EEPROM; учитель (teach ±1) подкрепляет
 *       выбор слова, но НЕ выбирает его. ~30% слов — лепет букв:
 *       буквенная сеть тоже продолжает учиться.
 * v2.26: ЧЕСТНЫЕ АДРЕСА НЕЙРОНОВ (код нейронов НЕ менялся): хаб верит
 *       номеру, который нейрон сообщает сам (N<id>;...). Раньше данные
 *       писались в слот ОПРАШИВАЕМОГО адреса — нейрон, сбросившийся на
 *       другой адрес/номер («пишет 1 вместо 2»), терял спайки и слова
 *       («их только два»). Теперь данные идут по слову нейрона, а смена
 *       адреса видна в мониторе: «[NET] нейрон сообщает №... с адреса...».
 * v2.27: СЛОВА ИЗ БОЛЬШОГО СЛОВАРЯ МОЗГА (ru_top.json — 30 000 слов):
 *       Python-мозг выбирает слово по частоте (перекос к частым, 15% —
 *       выученные из облака) и присылает его RPC word_push. Скетч
 *       произносит его ТОЛЬКО ЧЕРЕЗ ОБЫЧНЫЙ КОНВЕЙЕР (буква за шагом:
 *       решения учителю, частотный тег нейронам, STIM/D6/мелодия D8,
 *       SAY=). Встроенные 64 слов — резерв (мост/мозг молчат). Если
 *       присланное слово есть среди 64 — идёт как словарное, и учитель
 *       подкрепляет выбор wordW/wordCtx; незнакомое — как свободное
 *       слово (буквенные веса учителя работают как раньше).
 *       Код нейронов НЕ менялся.
 * v2.28: НАЗНАЧЕНИЕ НОМЕРОВ НЕЙРОНАМ (SETID) — RPC neuro_assign: слоты
 *       0..11 опрашиваются; пустой слот предлагается в ОБЩИЙ ВЫЗОВ
 *       (адрес 0) командой "SETID;<n>" — её берёт плата-нейрон БЕЗ
 *       номера (прошивка neuron_node v2.6: номер хранится в EEPROM и
 *       переживает ребут). Так лечится «слипание» (несколько плат с
 *       одним ID на одном адресе): перешейте нейроны прошивкой v2.6
 *       (одинаковой для всех!) и скажите мозгу «нейроны» — свободные
 *       слоты разойдутся по платам. Пустые платы подключайте ПО ОДНОЙ.
 * v2.29: СБРОС НОМЕРОВ НЕЙРОНОВ — RPC neuro_reset: всем платам в ОБЩИЙ
 *       ВЫЗОВ уходит "CLR_ID" — прошивка neuron_node v2.7 стирает номер
 *       из EEPROM и снова слушает общий вызов (становится «сиротой»).
 *       Нужен, если в EEPROM уже лежат ДУБЛИ номеров: скажите мозгу
 *       «нейроны сброс», затем подключайте платы ПО ОДНОЙ и запускайте
 *       «нейроны» (neuro_assign) — номера разойдутся без конфликтов.
 * v2.30: ПРИЁМНИК КАДРОВ КАМЕРЫ ПО UART: ESP32-CAM (скетч
 *       sketch/esp32cam_uart v1.0) шлёт JPEG-кадры ПО ПРОВОДУ в формате
 *       «буфера» (A5 5C | тип | seq | len | crc16/XMODEM | payload).
 *       Приём НЕБЛОКИРУЮЩИЙ (camUartTick в loop, парсер пересинхронизируется
 *       по магии, битые кадры по CRC отбрасываются). Целый кадр лежит в
 *       буфере и отдаётся мозгу кусками base64 (RPC cam_frame_info +
 *       cam_chunk "seq:off" — лимит сообщения моста 8 КБ не рвётся).
 *       Python-мозг с ключом cam_url = "uart" собирает кадр и несёт в
 *       облако тем же конвейером (YOLO/стрим /cam/буфер -> платы).
 * v2.33: МОСТ БОЛЬШЕ НЕ ЗАМЕРЗАЕТ НА «НЕЙРОНАХ» (причина таймаутов
 *       word_push/cloud_buf_set/chat_stim/say_wave): rpcNeuroAssign
 *       держал delay(400) на КАЖДЫЙ нейрон — 12 нейронов = 4.8 с
 *       БЛОКИРОВКИ loop() внутри Bridge-обработчика. По правилу
 *       Arduino («Bridge functions must be non-blocking — the Bridge
 *       will time out if the MCU function takes too long») все RPC,
 *       пришедшие в этом окне, отваливались по таймауту, а очередь
 *       Python-мозга копила устаревшие вызовы. Теперь назначение —
 *       ГОСУДАРСТВЕННАЯ МАШИНА: обработчик только ставит флаг и
 *       отвечает мгновенно, шаг по ОДНОМУ нейрону делает
 *       neuroAssignTick() из loop() (без единого delay), прогресс
 *       отдаётся новым RPC neuro_assign_poll. Скетч v2.33.
 * v2.34: СЛОВА КАЖДЫЕ 0.5 С — ПАМЯТЬ НА КАЖДОЕ СЛОВО. Мозг шлёт слова
 *       раз в 0.5 с (было 8-11 с), а конвейер произносит слово за
 *       ~0.4-1.5 с: старый слот на ОДНО слово терял всё, кроме последнего.
 *       Теперь каждое слово встаёт в КОЛЬЦЕВУЮ ОЧЕРЕДЬ (WQ_N = 20) и
 *       произносится по порядку; переполнение — честный счётчик wordQDrop.
 *       Мозг видит глубину очереди и счётчики через RPC word_q. Темп
 *       букв поднят: LETTER_TICK_MS 650 -> 80 (слово из 3 букв ≈ 0.4 с),
 *       GEN_PULSE_MS 260 -> 70, D6_STEP_MS 220 -> 50.
 * v2.38: ЗНАКИ ПРЕПИНАНИЯ ОТ МОЗГА (просьба владельца: «введи запятую,
 *       точку, восклицательный и вопросительный знаки в нейросеть, НЕ
 *       меняя саму сеть, — чтобы она их тоже выбирала»): мозг добавил
 *       знаки в СЛОВАРЬ (ru_top.json) и шлёт их word_push, как слова.
 *       Скетч: rpcWordPush принимает ОДИНОЧНЫЙ знак (",", ".", "!", "?"),
 *       знак из очереди проводится механикой boardMarkTick — запятая
 *       встаёт между словами (", "), точка/!/ ? завершают фразу (SAY,
 *       on_say, on_letter). СЕТЬ БУКВ ПОЛНОСТЬЮ ПРЕЖНЯЯ: 10x36,
 *       36 выходов (33 буквы + пробел + запятая + точка), веса в EEPROM,
 *       решения учителю — никаких новых классов и выходов; знаки входят
 *       словарём, а не сетью. Код нейронов НЕ менялся.
 * v2.6: точечное обучение — RPC teach_last (мгновенная оценка последней
 *       буквы, диктант) и teach_shape (своя награда каждой букве фразы):
 *       кредит выдаётся ТОЙ букве, что его заслужила, а не всей фразе.
 * v2.6a: FIX компиляции — сигнатура netTeachOne переведена на встроенные
 *       типы (int8_t*, uint8_t, int8_t): авто-прототипы препроцессора Arduino
 *       вставляются ДО объявления struct LetterDec, из-за чего пользовательский
 *       тип в сигнатуре ломал сборку ('LetterDec' was not declared).
 * ----------------------------------------------------------------------------
 * Что делает этот скетч:
 *  1. Опрашивает 12 нейронов-Ардуино по SoftwareWire (I2C на обычных пинах
 *     D2/D3) ИЛИ по software-RX/TX (SoftwareSerial D2/D3 через мультиплексор
 *     74HC4067 на A0..A3) — режим выбирается константой LINK_SW_WIRE.
 *  2. Собирает их "спайки" и слова в буфер val_c (текстовый канал мозга).
 *  3. Анализирует val_c (статистика, FNV-1a-хеш, топ-нейрон) и ПЕЧАТАЕТ
 *     результат в буфер total_val_c — ЕДИНСТВЕННЫЙ буфер, который читает
 *     MicroPython/Python-часть с Linux-стороны UNO Q.
 *  4. Принимает от Linux-стороны: val_b (сводка YOLO с камеры) и chat_out
 *     (текст из чата) — chat_out рассылается нейронам как стимул.
 *  5. ГЕНЕРАТОР ЧАСТОТЫ (v1.5): меандр на ОДНОМ пине D4 -> A0 ВСЕХ нейронов
 *     (параллельная шина) с ОБЩЕЙ ЗЕМЛЁЙ. Частота ЖИВАЯ — синтезируется из
 *     четырёх источников:
 *        + камера   (val_b: сколько объектов видит YOLO)   — до +500 Гц
 *        + микрофон (D12/D13: звук, который слышит мозг)   — до +500 Гц
 *        + текст    (что ему написали / что пишет сам:     — до +400 Гц
 *                    chat_out, собственные STIM, слова нейронов)
 *        + спайки   (внутренняя активность 12 нейронов)    — до +300 Гц
 *     В покое 120 Гц, максимум 2000 Гц. Нейроны САМИ измеряют эту частоту
 *     на своём A0 и меняют веса перцептронов пропорционально ей (пластика).
 *     Дублирующий цифровой канал "GEN;<частота>" по I2C/SoftSerial оставлен
 *     как резерв и калибровочная ссылка.
 *  6. КЭШ/БУФЕР ОБЛАКА (v1.3): Linux-сторона сама КАЧАЕТ буфер с сервера
 *     облака (GET /api/buffer на платформе mozg12-cloud), сохраняет кэш в
 *     memory/cloud_buffer.json и кладёт сводку ключом cloud_buf в мост;
 *     скетч принимает её, выводит в total_val_c полем CLD= и рассылает
 *     платам-нейронам командой "BUF;<фрагмент>" — нейроны «слышат» облако.
 *  7. РЕЕСТР ФУНКЦИЙ (v1.4): новые возможности мозга добавляют на облаке
 *     (POST /api/skills), мозг их скачивает, изучает перцептронами и кладёт
 *     имя изученной функции ключом skill_out — скетч выводит её в total_val_c
 *     полем SKL= и рассылает нейронам командой "SKIL;<имя>" (вспышка LED).
 *  8. Обмен с Linux-стороной: библиотека Arduino_Bridge (ключи total_val_c,
 *     val_c, val_b, chat_out, cloud_buf, skill_out, speak, voice). Если
 *     библиотеки нет — автоматический запасной текстовый протокол GETK/PUTK.
 *  9. ДИНАМИК (v1.9): пин D8 — «МОТИВАЦИЯ ГОВОРИТЬ»:
 *      - когда мозг собирается ответить (новый chat_out) или озвучивает
 *        мысль/реплику (ключ "speak" от Linux), хаб издаёт фразу из 2-4
 *        тонов, построенных от ТЕКУЩЕЙ ЧАСТОТЫ ШИНЫ genHz (квинтовые ходы);
 *      - когда текст-канал или спайки высоки (мозг «хочет говорить») —
 *        короткий сигнал готовности не чаще раза в VOICE_IDLE_MS;
 *      - динамик -> воздух -> микрофон D12/D13 -> micLevel -> частота шины:
 *        голосовая ПЕТЛЯ самостимуляции (мозг слышит себя и активнее
 *        меняет веса). Анти-заводка: если микрофон перегружен (micLevel>90
 *        дольше 3 с), голос молчит VOICE_COOL_MS;
 *      - вкл/выкл — ключом "voice" от Linux (Cloud Studio, панель «Настройки»);
 *      - счётчик фраз выводится в total_val_c полем VOX=.
 * 10. НАСТРОЙКИ СКЕТЧА (v2.2): частоты шины редактируются в Cloud Studio
 *      (панель «Настройки» -> «Скетч»), Linux-сторона передаёт их ключом
 *      "hzcfg" = "min,max,cam,mic,txt,spk"; хаб применяет на ходу и хранит
 *      в EEPROM — переживают перезагрузку, перепрошивка не нужна.
 * 11. БУКВЕННЫЙ ГЕНЕРАТОР (v2.3): СВОЯ нейросеть букв (перцептрон 10x36)
 *      выдаёт число 1..33 -> буква русского алфавита, плюс классы 34/35/36 —
 *      ПРОБЕЛ, ЗАПЯТАЯ, ТОЧКА. Буквы механикой собираются в слова, слова —
 *      во фразы:
 *        - каждое число-буква помечается на ЧАСТОТНОЙ ШИНЕ: генератор D4
 *          выдаёт частоту-тег (min + номер буквы в полосе шины) и рассылает
 *          "GEN;<тег>" — платы-нейроны слышат НОМЕР БУКВЫ своей пластикой
 *          (код нейронов НЕ меняется: они и так меряют частоту на A0);
 *        - каждое СЛОВО уходит нейронам как "STIM;<слово>" и произносится
 *          динамиком D8 мелодией нот (произношение словами);
 *        - завершённая ФРАЗА кладётся в итоговый буфер total_val_c полем
 *          SAY= — Linux-сторона читает её, говорит СЛОВАМИ (TTS) и
 *          отправляет в чат; LLM-ядро работает УЧИТЕЛЕМ: оценивает фразу
 *          (ключ "teach" = +1/-1) и подкрепляет выбор буквы — УЧИТ мозг,
 *          но НЕ выбирает букву за него; веса нейросети букв в EEPROM;
 *        - буквогенератор живёт и в val_c ("G<номер>:<буква>|"), и в чате.
 * 12. APP LAB (v2.4): обмен с Python-стороной приложения — ОФИЦИАЛЬНЫЙ
 *     мост Arduino_RouterBridge: скетч шлёт события notify
 *     (on_state/on_letter/on_word/on_say/on_msg), Python вызывает методы
 *     (chat_stim/val_b_set/cloud_buf_set/skill_out_set/set_voice/
 *     set_hzcfg/speak_tone/teach_score — обработчики в потоке loop).
 *     Сырой протокол GETK/PUTK и старый Arduino_Bridge в App Lab
 *     ОТКЛЮЧЕНЫ: UART занят роутером RPC (иначе ломается поток).
 *
 * ПРОВОДКА (v1.9):
 *   D4  хаба -> A0 КАЖДОЙ платы-нейрона (все A0 соединены параллельно)
 *   GND хаба -> GND всех нейронов  (ОБЩАЯ ЗЕМЛЯ ОБЯЗАТЕЛЬНА)
 *   D12 хаба -> DO модуля звука/микрофона №1 (KY-037/KY-038, цифровой выход)
 *   D13 хаба -> DO модуля звука №2 (второй микрофон или датчик шума)
 *   D8  хаба -> динамик (через транзисторный ключ/усилитель NPN, например
 *               2N2222: база через резистор 470 Ом на D8, эмиттер на GND,
 *               коллектор на динамик 4-8 Ом, динамик на +5В; можно и пьезо
 *               прямо на D8/GND)
 *
 * Канал YOLO: сама детекция выполняется на Linux-стороне UNO Q (микропитон/
 * python-приложение yolo_val_b.py по кадрам ESP32-CAM). Скетч получает ГОТОВУЮ
 * сводку детекций в val_b и вплетает её в total_val_c — т.е. анализ
 * total_val_c является YOLO-базированным: видео-канал и текст-канал
 * сливаются в один буфер.
 * ========================================================================== */

#include <Arduino.h>

/* ---- STRL-FALLBACK (begin): strlcpy/strlcat для ядра Zephyr (UNO Q) -----
 * Линкер arm-zephyr-eabi не содержит BSD-функций strlcpy/strlcat, а их
 * используют и этот скетч, и библиотека Arduino_RouterBridge (monitor.h).
 * Определяем их как СЛАБЫЕ символы: там, где libc уже даёт свои реализации
 * (AVR/avr-libc 2.x, ESP32/newlib), наши определения линкер просто
 * отбрасывает — конфликта нет. Семантика BSD: возвращают длину src,
 * всегда NUL-завершают dst (при dsize > 0). */
extern "C" __attribute__((weak)) size_t strlcpy(char *dst, const char *src, size_t dsize) {
  size_t slen = strlen(src);
  if (dsize != 0) {
    size_t copy = (slen >= dsize) ? dsize - 1 : slen;
    memcpy(dst, src, copy);
    dst[copy] = '\0';
  }
  return slen;
}
extern "C" __attribute__((weak)) size_t strlcat(char *dst, const char *src, size_t dsize) {
  size_t dlen = 0;
  while (dlen < dsize && dst[dlen] != '\0') dlen++;
  if (dlen == dsize) return dsize + strlen(src);
  size_t slen = strlen(src);
  size_t room = dsize - dlen;
  size_t copy = (slen >= room) ? room - 1 : slen;
  memcpy(dst + dlen, src, copy);
  dst[dlen + copy] = '\0';
  return dlen + slen;
}
/* ---- STRL-FALLBACK (end) ----------------------------------------------- */

/* ----------------------------- НАСТРОЙКИ --------------------------------- */
#define LINK_SW_WIRE   1        // 1 = SoftwareWire (SDA=D2, SCL=D3)
                                // 0 = SoftwareSerial RX=D2, TX=D3 + мультиплексор 74HC4067 (A0..A3)
#define NEURONS        12       // количество нейронов-плат
#define I2C_BASE_ADDR  0x10     // адреса нейронов 0x10..0x1B
#define TEXT_MAX       16       // макс. длина слова от нейрона (UTF-8 байты)
#define VAL_C_SIZE     512      // буфер val_c (текст)
#define VAL_B_SIZE     128      // буфер val_b (сводка YOLO)
#define TOTAL_SIZE     640      // буфер total_val_c (анализ; v2.3: +LTR/CHR/WRD/SAY)
#define CHAT_OUT_SIZE  96       // текст из чата -> нейронам
#define CLOUD_BUF_SIZE 128      // сводка буфера/кэша облака (ключ cloud_buf)
#define SKILL_OUT_SIZE 24       // имя изученной функции облака (ключ skill_out)

#define POLL_MS        60       // v2.18: опрос нейрона раз в 60 мс (было 25).
                                 // С 12 подключёнными нейронами loop был почти
                                 // всегда занят ожиданием — RPC-обработчики
                                 // (provide_safe исполняются в loop-хуке)
                                 // голодали, и мост «молчал». 60 мс = цикл
                                 // 720 мс: спайки/слова доходят в окна анализа,
                                 // а мост остаётся отзывчивым
#define BRIDGE_MS      500      // синхронизация с Linux-стороной
#define ANALYZE_MS     500      // пересчёт total_val_c и целевой частоты

/* ------- ГЕНЕРАТОР ЧАСТОТЫ: один пин, шина на A0 всех нейронов ----------- */
#define GEN_PIN        4        // ЕДИНСТВЕННЫЙ выход генератора (D4) -> A0 нейронов
#define GEN_MIN_HZ     120      // частота в покое (низкая -> медленная пластика)
#define GEN_MAX_HZ     2000     // потолок при полном всплеске всех каналов
#define GEN_DEADBAND   5        // рассылать "GEN;<hz>" при изменении >= 5 Гц
#define CAM_HZ_SPAN    500      // вклад камеры:  0..+500 Гц (детекции YOLO в val_b)
#define MIC_HZ_SPAN    500      // вклад микрофона: 0..+500 Гц (звук на D12/D13)
#define TXT_HZ_SPAN    400      // вклад текста:  0..+400 Гц (чат + свои реплики)
#define SPK_HZ_SPAN    300      // вклад спайков: 0..+300 Гц (активность нейронов)

/* ------- МИКРОФОН / ЗВУК (цифровые выходы модулей) ----------------------- */
#define MIC_PINS_N     2
const uint8_t MIC_PIN[MIC_PINS_N] = {10, 11};  // DO модулей звука (KY-037/038); v2.94: D12/D13 -> D10/D11
/* v2.94: ГОЛОСОВОЙ МОДУЛЬ ELECHOUSE VR3 (V3.1) — UART 9600 на D12/D13.
 *   TXD модуля -> делитель 1к/2к -> D12 (приём платы)
 *   RXD модуля <- D13 (передача платы), VCC -> 5V, GND -> GND
 * Аппаратный UART (D0/D1) занят камерой — приём программный: по фронту
 * старт-бита прерывание читает байт (~1 мс), передача — по micros(). */
#define VR_RX_PIN      12
#define VR_TX_PIN      13
#define VR_BIT_US      104      // 9600 бод
#define MIC_WIN_MS     40       // окно подсчёта переходов звука, мс
#define MIC_HITS_MAX   12       // столько переходов за окно = 100% громкости

/* ------- ДИНАМИК (v1.9): МОТИВАЦИЯ ГОВОРИТЬ ------------------------------ */
#define SPEAKER_PIN    8        // D8 -> транзисторный ключ -> динамик 4-8 Ом
#define VOICE_IDLE_MS  6000     // минимум между спонтанными сигналами готовности
#define VOICE_READY    55       // уровень txtLvl/spkLvl, при котором мозг «хочет говорить»
#define VOICE_MS       110      // длительность одной посылки тона, мс
#define VOICE_GAP_MS   60       // пауза между посылками, мс
#define VOICE_TONE_MAX 1100     // верхняя базовая частота голоса, Гц
#define VOICE_COOL_MS  10000    // анти-заводка: тишина после перегруза микрофона
#define MIC_HOT_LEVEL  90       // micLevel, считающийся перегрузом
#define MIC_HOT_MS     3000     // сколько мс держится перегруз -> кулдаун голоса

/* ------- БУФЕР СЛОВ НА D6 (v2.22): D6 = PWM -------------------------------
 * На D6 (PB1 -> TIM3_CH4, аппаратный PWM 500 Гц) хаб выводит БУФЕР, В
 * КОТОРОМ СЛОВА — байты текста (UTF-8), а НЕ номер буквы. Байт идёт СЫРЫМ
 * уровнем: duty = байт/255, напряжение U = 3.3В · байт/255; один байт
 * звучит D6_STEP_MS мс. Внешний читатель (вольтметр или A1 другой платы)
 * восстанавливает байты: N = round(U / 3.3 * 255) — и собирает из них
 * СЛОВА. На пин попадают:
 *   1) своё готовое слово — буфер genWord + хвост (пробел/запятая/точка),
 *      ставится в очередь в wordCommit() при каждом завершённом слове;
 *   2) фраза мозга — Python шлёт RPC "d6seq" (номера букв, формат не
 *      менялся), скетч декодирует их в ТЕКСТОВЫЙ буфер (RU33 + пробелы)
 *      и проигрывает по байтам. Номера букв на D6 больше не выходят.
 * Пока играет одна посылка, новая её вытесняет (начинается немедленно). */
#define NN_OUT_PIN     6        // D6 = PWM-выход буфера слов (UTF-8 байты)

/* v2.92: дискретизация энергии конденсатора на D6 — частицы (гравитоны/мюоны/фотоны).
 * При включённых галочках в облаке (вкладка Общие) на D6 периодически выдаются
 * дискретные уровни PWM, имитирующие кванты энергии частиц и фоновый шум. */
bool partGrav = false, partMuon = false, partPhot = false;
uint16_t genFreqOverride = 0;   // 0 = авто, иначе принудительная частота генератора
bool cpuFreqLink = false;
float freqBandMinMhz = 100.0f, freqBandMaxGhz = 4.0f;
uint32_t partNextMs = 0;
uint8_t partPhase = 0;

/* v2.93: шум конденсатора (аналоговый пин) как стимул + ускорение весов от частоты D6.
 * Подключи выход конденсатора (или RC-цепь с шумом) к CAP_NOISE_PIN.
 * Высокий шум -> STIM нейронам + временный подъём genHz.
 * Активность/частота на D6 (частицы + PWM) ускоряет подбор весов (learningScale). */
#define CAP_NOISE_PIN  A4          // аналоговый вход шума конденсатора
uint16_t capNoise = 0;             // текущий уровень шума 0..255
uint16_t d6Activity = 0;           // оценка активности/частоты на D6 0..255
uint8_t  learningScale = 1;        // множитель шага весов (1..4)
uint32_t noiseStimMs = 0;

/* v2.22: буфер СЛОВ для D6 (текст, не номера букв) */
#define D6_TXT_MAX     208      // максимум байт текста в одной посылке
#define D6_STEP_MS     50      // длительность одного байта, мс
                               // (v2.34: было 220 — буфер слова на D6
                               //  успевает за темпом слов)
char     d6Txt[D6_TXT_MAX + 1]; // буфер слов: UTF-8 байты (пуст = не играем)
uint16_t d6Len = 0;             // сколько байт в буфере (0 = не играем)
uint16_t d6Pos = 0;             // сколько байт уже сыграли
uint32_t d6NextMs = 0;          // millis() следующего байта

/* v2.46: ЗНАКОВЫЙ КАДР ЧАСТОТЫ НА D6 (опция облака «отрицательная частота
 * на D6»). На пине нет ни отрицательного напряжения (0…3.3 В), ни
 * отрицательной частоты (несущая 500 Гц фиксирована) — поэтому ЗНАК
 * передаётся КОДОМ: после текста играется кадр из 3 байт + 0:
 *   [0xFE = плюс | 0xFF = минус][старший байт |Δf|][младший байт |Δf|]
 * (Δf в Гц, 0..65535). Байты 0xFE/0xFF в UTF-8 не встречаются, поэтому
 * кадр нельзя спутать с текстом. Кадр приходит RPC "d6freq" ("-37"). */
uint8_t  d6Frame[3] = {0, 0, 0};
bool     d6FramePend = false;           // кадр ждёт конца текста
uint8_t  d6FrPos = 4;                   // 0..3 играем кадр (3 = тишина), 4 = нет

/* v2.48: КАДР ESP32-CAM НА D6 — САМИМ КАДРОМ (растр), а не байтами файла.
 * Python уменьшает кадр до 16x12 серых точек и шлёт RPC "d6img"; каждая
 * точка звучит УРОВНЕМ (duty = яркость, 1..254), строка за строкой, как
 * развёртка телевизора. Служебные уровни: 255 — начало/конец кадра (дважды
 * в начале), 0 вместо точки — конец строки. Поток точек и поток мысли идут
 * по одному пину с ЦИКЛОМ из 4 слотов по D6_STEP_MS: слот 0 — байт мысли
 * (или кадр знака), слот 1 — точка кадра (отставание кадра от мысли = pi/2),
 * слоты 2-3 — тишина. При отрицательной частоте (опция облака) точка идёт в
 * слоте 3 — отставание -pi/2, т.е. обратное направление «вращения»; темп
 * слотов тот же. Это и есть честный смысл знака: порядок двух потоков. */
#define D6_IMG_W   16
#define D6_IMG_H   12
#define D6_IMG_N   (D6_IMG_W * D6_IMG_H)
#define D6_IMG_LEN (2 + D6_IMG_H * (D6_IMG_W + 1) + 1)   // поток служебных+точек
uint8_t  d6ImgIn[D6_IMG_N];             // принимаемый кадр (по кускам)
uint8_t  d6Img[D6_IMG_N];               // играемый кадр
bool     d6ImgInNeg = false;
bool     d6ImgRdy = false;              // новый кадр принят целиком
bool     d6ImgRun = false;              // развёртка идёт
bool     d6ImgNeg = false;              // отставание -pi/2 (отрицательная частота)
uint16_t d6ImgIdx = 0;                  // сколько элементов потока сыграно
uint8_t  d6Ph = 0;                      // слот цикла 0..3
uint32_t d6SlotMs = 0;

uint8_t d6ImgTok(uint16_t i) {
  if (i < 2) return 255;
  uint16_t k = i - 2;
  uint16_t r = k / (D6_IMG_W + 1), c = k % (D6_IMG_W + 1);
  if (r >= D6_IMG_H) return 255;        // конец кадра
  if (c == D6_IMG_W) return 0;          // конец строки
  return d6Img[r * D6_IMG_W + c];
}

/* v2.48: полярность меандра на D4 (отрицательная частота на шине):
 * 0 — симметричный меандр, +1 — высокий уровень 1/3 периода, -1 — 2/3
 * (инвертированная полярность). Период (частота) тот же; нейроны считают
 * ФРОНТЫ, поэтому частота для них не меняется. */
int8_t   d4Pol = 0;
/* Генератор D4 (объявлено рано: нужно кадру D4 ниже) */
uint16_t genHz = GEN_MIN_HZ;          // ТЕКУЩАЯ частота на пине D4, Гц
bool     genOut = false;              // текущий уровень на D4
uint32_t nextEdgeUs = 0;              // время следующего фронта (догоняющий планировщик)

/* v2.49: ЧИСТЫЙ КАДР НА D6 (режим облака d6_cammode = "pure"): без PWM-уровней
 * и без байтов. Пин переводится в обычный цифровой выход (digitalWrite), а
 * кадр 32x24 чёрно-белых точек (серое — упорядоченный дизеринг на стороне
 * Python) «рисуется» самим уровнем сигнала, как факсимильная развёртка:
 * одна точка = один Манчестер-слот D6P_HALF_US*2: белая = ВЫСОКИЙ->НИЗКИЙ,
 * чёрная = НИЗКИЙ->ВЫСОКИЙ. В данных подряд бывает не более 2 половинок
 * одного уровня, поэтому служебные сигналы отличимы длиной уровня:
 *   начало кадра (слитно со строкой 0): НИЗ x2, ВЫСОКИЙ x6, НИЗ x2;
 *   начало строки: ВЫСОКИЙ x3, НИЗ x2, затем 32 точки (срез после x3 — отсчёт);
 *   отличить кадр от строки приёмник может независимо от такта: отношение
 *   длины ВЫСОКОГО к следующему НИЗКОМУ >= 2 (6:2) — кадр, иначе (3:2 или 3:3)
 *   — строка;
 *   конец кадра: НИЗ.
 * Кадр идёт строками: между строками loop() свободен. ВАЖНО: пока идёт ОДНА
 * строка (~70 мс), loop() занят отсчётом микросекунд (D4 при этом
 * поддерживается вызовом freqTick()). Один кадр ~1,7 с (против ~41 с PWM).
 * Согласование с мыслью: «плюс» — кадр запаздывает за мыслью на pi/2 (одна
 * четверть цикла из 4 слотов D6_STEP_MS; играется ПОСЛЕ мысли с паузой
 * D6_STEP_MS; мысль, пришедшая во время кадра, кадр прерывает); «минус» —
 * кадр опережает мысль на pi/2 (мысль, пришедшая во время кадра, ждёт его
 * конца + D6_STEP_MS). Пока не проверено на железе UNO Q: после analogWrite()
 * digitalWrite() должен вернуть пин в обычный выход — если ядро этого не
 * делает, нужен pinMode(NN_OUT_PIN, OUTPUT) перед кадром (он есть). */
#define D6P_W        32
#define D6P_H        24
#define D6P_N        (D6P_W * D6P_H)
#define D6P_HALF_US  1000UL
uint8_t  d6pIn[D6P_N];                  // принимаемый кадр: 0/1 на точку
uint8_t  d6pBuf[D6P_N];                 // играемый кадр
bool     d6pInNeg = false, d6pRdy = false;
bool     d6pNeg = false, d6pRun = false;
int16_t  d6pRow = 0;                    // строка 0..H-1 (в строке 0 — ещё и заголовок кадра)
uint32_t d6pNextMs = 0, d6IdleSince = 0, d6pGapUntil = 0;

static inline void d6pSlot(uint8_t lvl, uint32_t &t) {
  digitalWrite(NN_OUT_PIN, lvl ? HIGH : LOW);
  t += D6P_HALF_US;
  while ((int32_t)(micros() - t) < 0) freqTick();   // D4 не стоит
}

void d6pEmit(int16_t row) {
  uint32_t t = micros();
  if (row == 0) {                                   // начало кадра + строка 0 слитно
    d6pSlot(0, t); d6pSlot(0, t);
    for (uint8_t i = 0; i < 6; i++) d6pSlot(1, t);
    d6pSlot(0, t); d6pSlot(0, t);
  }
  for (uint8_t i = 0; i < 3; i++) d6pSlot(1, t);    // начало строки
  d6pSlot(0, t); d6pSlot(0, t);
  for (uint8_t x = 0; x < D6P_W; x++) {
    uint8_t b = d6pBuf[row * D6P_W + x];
    d6pSlot(b ? 1 : 0, t);                          // белая: ВЫСОКИЙ -> НИЗКИЙ
    d6pSlot(b ? 0 : 1, t);                          // чёрная: НИЗКИЙ -> ВЫСОКИЙ
  }
  d6pSlot(0, t);
}

/* v2.50/v2.51: ЧИСТЫЙ КАДР НА D4 (опция облака d4_camframe) — тот же метод,
 * что на D6 (Манчестер: белая ВЫСОКИЙ->НИЗКИЙ, чёрная НИЗКИЙ->ВЫСОКИЙ), но
 * ТАКТ кадра — ЗНАКОВАЯ ЧАСТОТА «ДЫХАНИЯ», которую задаёт внутренняя тензорная
 * сеть платы (Python: профиль из 24 частот, по одной на строку, в пределах
 * -2000..+2000 Гц; ни LLM, ни нейроны её не выбирают). Половина слота
 * = 1/(2*|f|), |f| не ниже D4F_MIN_HZ (200 Гц) и не выше D4F_MAX_HZ (2000 Гц).
 * ЗНАК частоты — КОД СТРОКИ: f < 0 -> после синхро ВЫСОКИЙ x5 идёт НИЗКИЙ x4
 * (у f > 0 — НИЗКИЙ x2) и точки кодируются наоборот (белая НИЗКИЙ->ВЫСОКИЙ).
 * Уровни не инвертируются, поэтому перепад знака между строками не склеивается
 * с паузой между строками. Реальная частота ведётся к целевой профиля не
 * быстрее ±25 % за строку; перед сменой знака |f| спускается до D4F_MIN_HZ
 * («пауза между вдохом и выдохом»).
 * Приёмник ведёт такт по синхро строки: ВЫСОКИЙ x5 в 4.0..6.7 прежних
 * половинок — синхро (данные не длиннее 2 половинок, т.е. до 2.7); следующий
 * НИЗКИЙ <3.5 половинок — «+», иначе «-» (данные после синхро могут добавить
 * к НИЗКОМУ x2 ещё одну половинку: 2..3 против 4..5).
 * Заголовок кадра слит со строкой 0: НИЗ x2, ВЫСОКИЙ x10, НИЗ x2 (отношение
 * к следующему НИЗКОМУ = 5, у синхро строки 2.5 или 1.25).
 * Пока идёт кадр, меандр генератора на D4 не выводится (freqTick молчит):
 * нейроны считают фронты и ~2 с видят частоту, зависящую от картинки; частые
 * кадры = заметное искажение темпа нейронов (так просил владелец). */
#define D4F_MIN_HZ 200
#define D4F_MAX_HZ 2000
uint8_t  d4fIn[D6P_N];
uint8_t  d4fBuf[D6P_N];
int16_t  d4fProf[D6P_H];                // целевая знаковая частота по строкам, Гц
bool     d4fProfOn = false;             // профиль задан (иначе: |genHz|, знак d4Pol)
bool     d4fRdy = false, d4fRun = false;
int16_t  d4fRow = 0;
uint32_t d4fNextMs = 0;
int16_t  d4fCur = 0;                    // текущая знаковая частота строки
uint16_t d4fLastHz = 0;                 // |f| последней строки (для статуса)
int8_t   d4fLastSign = 1;

static inline void d4fSlot(uint8_t lvl, uint32_t &t, uint32_t half) {
  digitalWrite(GEN_PIN, lvl ? HIGH : LOW);
  t += half;
  while ((int32_t)(micros() - t) < 0) { }
}

/* следующая знаковая частота: к цели не быстрее ±25 % за строку, смена знака
 * через D4F_MIN_HZ */
int16_t d4fStep(int16_t cur, int16_t target) {
  int16_t tg = target;
  if (tg > D4F_MAX_HZ) tg = D4F_MAX_HZ;
  if (tg < -D4F_MAX_HZ) tg = -D4F_MAX_HZ;
  int16_t sc = cur < 0 ? -1 : 1, st = tg < 0 ? -1 : 1;
  int32_t mc = cur < 0 ? -cur : cur, mt = tg < 0 ? -tg : tg;
  if (mt < D4F_MIN_HZ) mt = D4F_MIN_HZ;
  if (mc < D4F_MIN_HZ) mc = D4F_MIN_HZ;
  if (sc != st) {                       // сначала вниз до минимума, потом знак
    if (mc <= D4F_MIN_HZ) return (int16_t)(st * D4F_MIN_HZ);
    mt = D4F_MIN_HZ; st = sc;
  }
  int32_t hi = mc * 125 / 100, lo = mc * 75 / 100;
  int32_t m = mt > hi ? hi : (mt < lo ? lo : mt);
  if (m < D4F_MIN_HZ) m = D4F_MIN_HZ;
  if (m > D4F_MAX_HZ) m = D4F_MAX_HZ;
  return (int16_t)(st * m);
}

void d4fEmit(int16_t row) {
  int16_t f;
  if (d4fProfOn) {
    f = (row == 0) ? d4fStep(d4fProf[0] < 0 ? -D4F_MIN_HZ : D4F_MIN_HZ, d4fProf[0])
                   : d4fStep(d4fCur, d4fProf[row]);
    if (row == 0) {                     // первая строка: прямо к цели (не быстрее 25 %)
      int16_t m0 = d4fProf[0] < 0 ? -d4fProf[0] : d4fProf[0];
      if (m0 < D4F_MIN_HZ) m0 = D4F_MIN_HZ;
      if (m0 > D4F_MAX_HZ) m0 = D4F_MAX_HZ;
      f = (int16_t)((d4fProf[0] < 0 ? -1 : 1) * m0);
    }
  } else {                              // без профиля: |genHz|, знак по d4Pol
    uint16_t g = genHz < D4F_MIN_HZ ? D4F_MIN_HZ : (genHz > D4F_MAX_HZ ? D4F_MAX_HZ : genHz);
    int16_t tg = (int16_t)(d4Pol < 0 ? -(int16_t)g : (int16_t)g);
    f = (row == 0) ? tg : d4fStep(d4fCur, tg);
  }
  d4fCur = f;
  bool inv = f < 0;
  uint16_t hz = (uint16_t)(f < 0 ? -f : f);
  uint32_t half = 500000UL / hz;
  d4fLastHz = hz; d4fLastSign = inv ? -1 : 1;
  uint32_t t = micros();
  if (row == 0) {                       // начало кадра + строка 0 слитно
    d4fSlot(0, t, half); d4fSlot(0, t, half);
    for (uint8_t i = 0; i < 10; i++) d4fSlot(1, t, half);
    d4fSlot(0, t, half); d4fSlot(0, t, half);
  }
  for (uint8_t i = 0; i < 5; i++) d4fSlot(1, t, half);        // синхро строки
  for (uint8_t i = 0; i < (inv ? 4 : 2); i++) d4fSlot(0, t, half);   // знак
  for (uint8_t x = 0; x < D6P_W; x++) {
    uint8_t b = d4fBuf[row * D6P_W + x];
    if (inv) b = !b;                    // «минус»: код точек наоборот
    d4fSlot(b ? 1 : 0, t, half);
    d4fSlot(b ? 0 : 1, t, half);
  }
  d4fSlot(0, t, half);
}

void d4fTick() {
  if (!d4fRun) {
    if (d4fRdy) {
      memcpy(d4fBuf, d4fIn, D6P_N);
      d4fRdy = false;
      pinMode(GEN_PIN, OUTPUT);
      d4fRun = true; d4fRow = 0; d4fNextMs = 0;
    }
    return;
  }
  if ((int32_t)(millis() - d4fNextMs) < 0) return;
  d4fEmit(d4fRow);
  d4fRow++;
  d4fNextMs = millis() + 3;
  if (d4fRow >= D6P_H) {
    d4fRun = false; d4fRow = 0;
    digitalWrite(GEN_PIN, genOut ? HIGH : LOW);   // меандр генератора возвращается
    nextEdgeUs = micros();
  }
}

/* true — пока чистый кадр владеет пином (идёт кадр или держится пауза «−pi/2») */
bool d6PureTick(bool thoughtBusy) {
  uint32_t now = millis();
  if (thoughtBusy) d6IdleSince = now;
  if (d6pRun) {
    if ((int32_t)(now - d6pNextMs) < 0) return true;
    d6pEmit(d6pRow);
    d6pRow++;
    d6pNextMs = millis() + 3;
    if (d6pRow >= D6P_H) {
      digitalWrite(NN_OUT_PIN, LOW);
      d6pRun = false; d6pRow = 0;
      d6IdleSince = millis();
      if (d6pNeg) d6pGapUntil = millis() + D6_STEP_MS;   // мысль после кадра
    }
    return true;
  }
  if (d6pGapUntil && (int32_t)(now - d6pGapUntil) < 0) return true;
  d6pGapUntil = 0;
  if (d6pRdy && !thoughtBusy && (int32_t)(now - d6IdleSince) >= (int32_t)D6_STEP_MS) {
    memcpy(d6pBuf, d6pIn, D6P_N);
    d6pNeg = d6pInNeg; d6pRdy = false;
    pinMode(NN_OUT_PIN, OUTPUT);                    // PWM снят: обычный выход
    d6pRun = true; d6pRow = 0; d6pNextMs = 0;
  }
  return false;
}

void d6PutText(const char *txt) {
  if (!txt || !txt[0]) return;
  if (d6pRun && !d6pNeg) {              // v2.49: «плюс» — мысль главнее кадра
    d6pRun = false; d6pRow = 0; digitalWrite(NN_OUT_PIN, LOW);
  }
  strlcpy(d6Txt, txt, sizeof(d6Txt));   // новая посылка вытесняет старую
  d6Len = (uint16_t)strlen(d6Txt);
  d6Pos = 0; d6NextMs = 0;              // начать немедленно
  d6FrPos = 4;                          // идущий кадр прерван новой фразой
}

/* Пины шины нейронов ("обычные пины", как и просили) */
#define BUS_SDA  2               // SoftwareWire: SDA | SoftwareSerial: RX
#define BUS_SCL  3               // SoftwareWire: SCL | SoftwareSerial: TX
const uint8_t MUX_PINS[4] = {A0, A1, A2, A3};   // адрес 74HC4067 (S0..S3)

/* ------- НАСТРОЙКИ СКЕТЧА ИЗ CLOUD STUDIO (v2.2) -------------------------
 * Частотная шина теперь редактируется в браузере: Studio (панель
 * «Настройки» -> «Скетч: частотная шина») шлёт мозгу cfg, Linux-сторона
 * передаёт её сюда ключом "hzcfg" = "min,max,cam,mic,txt,spk" (Гц).
 * Хаб применяет значения НА ХОДУ и сохраняет в EEPROM — они переживают
 * перезагрузку. Значение 0 = оставить текущее. Ключи/поля:
 *   min  = покой генератора  (60..1000 Гц, по умолчанию GEN_MIN_HZ)
 *   max  = потолок           (300..4000 Гц, по умолчанию GEN_MAX_HZ)
 *   cam  = вклад камеры      (0..1000 Гц, по умолчанию CAM_HZ_SPAN)
 *   mic  = вклад микрофона   (0..1000 Гц, по умолчанию MIC_HZ_SPAN)
 *   txt  = вклад текста      (0..1000 Гц, по умолчанию TXT_HZ_SPAN)
 *   spk  = вклад спайков     (0..1000 Гц, по умолчанию SPK_HZ_SPAN) */
#if __has_include(<EEPROM.h>)
  #define USE_EEPROM 1
  #include <EEPROM.h>
#else
  #define USE_EEPROM 0
#endif
#define HZCFG_MAGIC 0xA5          // EEPROM[0]: признак записанных настроек
#define HZCFG_ADDR  1             // дальше 6 значений uint16 (little-endian)
uint16_t cfgMinHz = GEN_MIN_HZ;
uint16_t cfgMaxHz = GEN_MAX_HZ;
uint16_t cfgCamSpan = CAM_HZ_SPAN;
uint16_t cfgMicSpan = MIC_HZ_SPAN;
uint16_t cfgTxtSpan = TXT_HZ_SPAN;
uint16_t cfgSpkSpan = SPK_HZ_SPAN;

/* ----------------------------- БИБЛИОТЕКИ -------------------------------- */
/* Приоритет транспортов (v2.4): 1. Arduino_RouterBridge — официальный мост
 * Arduino App Lab (MessagePack-RPC); 2. старый Arduino_Bridge (ключи);
 * 3. текстовый GETK/PUTK. В App Lab используется ТОЛЬКО RouterBridge. */
#if __has_include(<Arduino_RouterBridge.h>)
  #define USE_RB 1
  #include <Arduino_RouterBridge.h>
#else
  #define USE_RB 0
#endif
#if USE_RB
  #define USE_BRIDGE 0
/* v2.68: ЖУРНАЛ СКЕТЧА БЕЗ БЛОКИРОВОК. Раньше HUB_OUT = Monitor: в библиотеке
 * RouterBridge каждая запись в Monitor, пока панель Monitor в App Lab не
 * открыта, делает БЛОКИРУЮЩИЙ RPC-вызов «mon/connected» (без тайм-аута), а
 * скетч печатает десятки строк — loop() замирал, сводки по мосту не шли
 * («мост: ждёт/молчит скетч»), а в Serial Monitor было пусто. Теперь строки
 * журнала уходят УВЕДОМЛЕНИЕМ on_log (не ждёт ответа) в приложение — их
 * видно в логах приложения и в панели платы; в Monitor они дублируются,
 * только если панель Monitor была открыта при старте скетча. */
String rpcDiag();               // v2.68: форвард (определена ниже)
class HubLog : public Print {
 public:
  bool mon = false;
  char buf[200];
  uint16_t n = 0;
  void begin(unsigned long) {}
  size_t write(uint8_t c) override {
    if (c == '\r') return 1;
    if (c == '\n') { line(); return 1; }
    if (n >= sizeof(buf) - 1) line();
    buf[n++] = (char)c;
    return 1;
  }
  size_t write(const uint8_t *b, size_t sz) override {
    for (size_t i = 0; i < sz; i++) write(b[i]);
    return sz;
  }
  void line() {
    buf[n] = 0;
    if (n) {
      utf8Fix(buf);                          // v2.87: журнал тоже чистим —
                                             // иначе 0x93/0x91 роняют мост
      if (Bridge) Bridge.notify("on_log", String(buf));
      if (mon) Monitor.println(buf);
    }
    n = 0;
  }
};
HubLog HubOut;
  #define HUB_OUT HubOut         /* журнал: on_log (+ Monitor, если открыт) */
#else
  #if __has_include(<Arduino_Bridge.h>)
    #define USE_BRIDGE 1
    #include <Arduino_Bridge.h>
  #else
    #define USE_BRIDGE 0
  #endif
  #define HUB_OUT Serial
#endif

#if LINK_SW_WIRE
  #if __has_include(<SoftwareWire.h>)
    #include <SoftwareWire.h>
    SoftwareWire NeuroBus(BUS_SDA, BUS_SCL);
    #define BUS_READY 1
  #else
    #include <Wire.h>          // запасной путь: аппаратный I2C (SDA/SCL)
    TwoWire& NeuroBus = Wire;
    #define BUS_READY 2        // предупреждение в Serial: поставьте SoftwareWire
  #endif
#else
  #if __has_include(<SoftwareSerial.h>)
    #include <SoftwareSerial.h>
    SoftwareSerial NeuroSer(BUS_SDA, BUS_SCL); // RX=D2, TX=D3
    #define BUS_READY 3
  #elif defined(ARDUINO_ARCH_STM32) && __has_include(<SoftwareSerial.h>)
    #include <SoftwareSerial.h>
    SoftwareSerial NeuroSer(BUS_SDA, BUS_SCL);
    #define BUS_READY 3
  #else
    #define NeuroSer Serial1   // последний запасной вариант
    #define BUS_READY 4
  #endif
#endif

/* ----------------------------- БУФЕРЫ/СОСТОЯНИЕ -------------------------- */
char val_c[VAL_C_SIZE];        // текст-канал: что "говорят" нейроны
char val_b[VAL_B_SIZE];        // видео-канал: сводка YOLO, приходит с Linux-стороны
char total_val_c[TOTAL_SIZE];  // РЕЗУЛЬТАТ АНАЛИЗА — его берёт микропитон
char chat_out[CHAT_OUT_SIZE];  // текст из чата -> стимул нейронам
char cloud_buf[CLOUD_BUF_SIZE]; // кэш+буфер, скачанный с сервера облака (CLD=)
char skill_out[SKILL_OUT_SIZE]; // последняя изученная функция облака (SKL=)

/* Форварды v2.3 (мелодия слова, нейросеть букв, генератор) */
void melStart();
void melTick();
void voiceWord(const char *w);
void netSave();
void netTeach(int8_t reward);
void netTeachOne(int8_t *x, uint8_t ch, int8_t reward);   // v2.6a: встроенные
                                                          // типы в сигнатуре,
                                                          // иначе авто-прототип
                                                          // ломается (LetterDec
                                                          // объявлен ниже)
void letterTick();
void appendGenC(uint8_t num, const char *tok);
void txtBump(uint8_t n);   // форвард: вызывается из hzcfgApply (ниже)
/* v2.67: СИНХРОНИЗАЦИЯ МОЗГОВ ПО ЧАСТОТЕ (связанные осцилляторы, как в
 * модели Курамото). Облако считает ОБЩИЙ РИТМ платформы — среднюю частоту
 * генераторов всех плат и «частоту» мозга облака — и шлёт её каждой плате;
 * Python передаёт её сюда RPC "sync_hz" ("гц,сила%"). Своя целевая частота
 * генератора (камера+микрофон+текст+спайки) подтягивается к общему ритму на
 * долю «силы» (0..60 %): fTarget += k·(syncHz − fTarget). Своё «дыхание» не
 * пропадает — платы сближаются, а не копируют друг друга. Нет обновлений
 * дольше SYNC_TTL_MS — связь снимается (плата живёт своим ритмом). */
#define SYNC_TTL_MS 45000UL
uint16_t syncHz = 0;
uint8_t  syncK = 0;                 // сила связи, % (0 — выкл.)
uint32_t syncTs = 0;
uint8_t camScore();        // форвард: вклад камеры (v2.3: вход нейросети букв)

struct NeuroStat {
  uint32_t spikes;             // спайки за окно (с момента прошлого чтения)
  char     word[TEXT_MAX + 1]; // последнее слово нейрона
  bool     alive;              // отвечал ли в последнем цикле
  uint8_t  miss;               // v2.23: пустых опросов подряд (см. MISS_DEAD)
};
NeuroStat ns[NEURONS];

uint8_t  pollIdx = 0;                 // чей сейчас опрос
uint32_t tPoll = 0, tBridge = 0, tAnalyze = 0;
uint32_t cycle = 0;

/* Генератор частоты: меандр на D4, частота дышит вместе с камерой/звуком/текстом */

/* Микрофон: активность звука на D12/D13 */
bool     micLast[MIC_PINS_N] = {false, false};
uint8_t  micHits = 0;                 // переходов уровня за окно MIC_WIN_MS
uint32_t tMic = 0;
uint8_t  micLevel = 0;                // 0..100 — сглаженная громкость

/* Динамик: голос мозга (v1.9) */
bool     voiceOn = true;              // вкл/выкл (ключ "voice", панель «Настройки»)
uint8_t  voxCount = 0;                // сколько фраз произнёс (VOX= в total_val_c)
uint8_t  voxSteps = 0;                // сколько посылок осталось в фразе
bool     voicePhase = false;          // true = посылка тона, false = пауза
bool     toneOut = false;             // уровень на SPEAKER_PIN
uint16_t toneHz = 440;                // ТЕКУЩАЯ частота посылки, Гц
uint32_t nextToneEdgeUs = 0;
uint32_t tVoicePhase = 0;
uint32_t lastPhraseMs = 0;            // когда закончилась последняя фраза
uint32_t micHotSince = 0;             // с какого момента микрофон перегружен
uint16_t voiceWave = 0;               // v2.14: сколько «речей» say_wave сыграно

/* Текст-канал: всплески от чата/своих реплик/облака (затухает сам) */
uint8_t  txtLevel = 0;                // 0..100

/* ------- БУКВЕННЫЙ ГЕНЕРАТОР (v2.3): константы и состояние ---------------- */
#define LETTER_TICK_MS 80      // одно решение нейросети букв, мс
                               // (v2.34: было 650 — слово раз в 8 с;
                               //  теперь слово из 3 букв ≈ 0.4 с —
                               //  темп «слово за полсекунды»)
#define WORD_MAX       10      // букв в слове
#define SENT_MIN       6       // минимальная длина фразы до точки, символов
#define SENT_MAX       40      // форс-точка на длине фразы, символов
#define SAY_MAX        42      // фраза в SAY= (символов; ≥ SENT_MAX+1)
#define DEC_MAX        26      // решений фразы в памяти учителя
#define GEN_PULSE_MS   70      // длительность частотного тега буквы, мс
                               // (v2.34: было 260 — окно тега короче темпа
                               //  букв, чтобы теги не слипались)
#define CL_SPACE       33      // класс 34 = пробел
#define CL_COMMA       34      // класс 35 = запятая
#define CL_DOT         35      // класс 36 = точка
#define NET_IN         10      // входов нейросети букв
#define NET_OUT        36      // 33 буквы + пробел + запятая + точка
#define NET_MAGIC_ADDR 40      // EEPROM: признак записанных весов букв
#define NET_WADDR      41      // EEPROM: веса NET_OUT*NET_IN байт
#define NET_MAGIC      0x5B
#define MEL_MAX        96      // шагов мелодии/речи (нота+пауза; v2.14: речь say_wave)

/* Русский алфавит в «номерном» порядке: 1..33 (UTF-8, по 2 байта) */
const char RU33[33][3] = {
  "А","Б","В","Г","Д","Е","Ё","Ж","З","И","Й","К","Л","М","Н","О","П",
  "Р","С","Т","У","Ф","Х","Ц","Ч","Ш","Щ","Ъ","Ы","Ь","Э","Ю","Я"};
const bool RU_VOW[33] = {                 // гласные: а е ё и о у ы э ю я
  1,0,0,0,0,1,1,0,0,1,0,0,0,0,0,1,0,0,0,0,1,0,0,0,0,0,0,0,1,0,1,1,1};

int8_t  netW[NET_OUT][NET_IN];            // веса нейросети букв (EEPROM)
bool    netDirty = false;
uint32_t netSaveAt = 0;                   // когда последний раз сохраняли веса

char    genWord[WORD_MAX * 2 + 2];        // текущее слово (UTF-8)
uint8_t genWordLen = 0;                   // байт в слове (букв*2)
char    genSent[SENT_MAX * 2 + 4];        // текущая фраза
uint8_t genSentLenB = 0;                  // байт во фразе
uint8_t genSentChars = 0;                 // символов во фразе
char    sayBuf[SAY_MAX * 2 + 2];          // последняя ЗАВЕРШЁННАЯ фраза (SAY=)
char    curChr[4] = "";                   // последняя буква/знак (для CHR=)
uint8_t lastClass = 255;                  // предыдущий класс (255 = ничего)
bool    afterPunct = false;               // предыдущий символ — запятая
uint16_t curLetterNum = 0;                // число 1..33 (0 = знак/пауза)

struct LetterDec { int8_t x[NET_IN]; uint8_t ch; };
LetterDec decisions[DEC_MAX];             // решения ТЕКУЩЕЙ фразы (для учителя)
uint8_t  decCount = 0;
LetterDec lastDec[DEC_MAX];               // решения ПОСЛЕДНЕЙ фразы (ждут оценки)
uint8_t  lastDecCount = 0;
bool     lastDecFresh = false;

uint32_t tLetter = 0;
uint32_t pulseUntil = 0;                  // частотный тег буквы активен до
uint16_t pulseHz = 0;                     // частота тега, Гц
uint32_t lettersMade = 0, wordsMade = 0, sentMade = 0;
uint16_t teachCount = 0;                  // сколько оценок учителя получено
uint8_t  spkLvlLast = 0;                  // уровень спайков из analyze (вход NN)

/* Мелодия слова (v2.3): каждая буква = своя нота на D8 */
struct MelStep { uint16_t hz; uint16_t ms; };
MelStep  mel[MEL_MAX];
uint8_t  melLen = 0, melIdx = 0;
bool     melTone = false;
uint32_t tMel = 0;

/* ----------------------------- УТИЛИТЫ ----------------------------------- */
uint32_t fnv1a(const char *s) {
  uint32_t h = 2166136261u;
  while (*s) { h ^= (uint8_t)*s++; h *= 16777619u; }
  return h;
}

/* Оставляем только безопасные символы, ';'->',' , ':'->'/' , '|'->'!' */
void sanitize(char *s) {
  for (; *s; s++) {
    uint8_t c = (uint8_t)*s;
    if (c == ';') *s = ',';
    else if (c == ':') *s = '/';
    else if (c == '|') *s = '!';
    else if (c < 0x20 || c == 0x7F) *s = ' ';
  }
}

/* v2.24: РЕМОНТ UTF-8 НА МЕСТЕ. sanitize() пропускает старшие байты
 * (0x80..0xFF) как есть, а с шумящей шины I2C приходит МУСОР: обрыв
 * посреди двухбайтовой буквы (0xD0/0xD1 без продолжения), случайные
 * 0xFF/0xAE/0x93. Такая строка в on_msg/on_state роняла декодер моста
 * Python («'utf-8' codec can't decode byte ...») и событие терялось
 * ЦЕЛИКОМ. Проходим строку: валидные последовательности (1..4 байта,
 * включая кириллицу D0/D1 xx) остаются как были, битый байт становится
 * пробелом. Строка гарантированно корректный UTF-8. */
void utf8Fix(char *s) {
  char *d = s;
  while (*s) {
    uint8_t c = (uint8_t)*s;
    uint8_t need;
    if (c < 0x80)            need = 0;
    else if ((c & 0xE0) == 0xC0) need = 1;
    else if ((c & 0xF0) == 0xE0) need = 2;
    else if ((c & 0xF8) == 0xF0) need = 3;
    else { *d++ = ' '; s++; continue; }   // одинокие 10xxxxxx / 11111xxx
    bool ok = true;
    for (uint8_t k = 1; k <= need; k++) {
      uint8_t cc = (uint8_t)s[k];
      if (!cc || (cc & 0xC0) != 0x80) { ok = false; break; }  // обрыв
    }
    if (!ok) { *d++ = ' '; s++; continue; }
    for (uint8_t k = 0; k <= need; k++) *d++ = s[k];  // буква цела
    s += need + 1;
  }
  *d = 0;
}

/* --------------------- НАСТРОЙКИ ЧАСТОТ (v2.2, STUDIO) -------------------- */
void broadcastGen();                  // форвард (определена ниже)

static void eewrite(int addr, uint8_t v) {
#if USE_EEPROM
  if (EEPROM.read(addr) != v) EEPROM.write(addr, v);
#else
  (void)addr; (void)v;
#endif
}

void hzcfgSave() {
  uint16_t *vals[6] = {&cfgMinHz, &cfgMaxHz, &cfgCamSpan,
                       &cfgMicSpan, &cfgTxtSpan, &cfgSpkSpan};
#if USE_EEPROM
  eewrite(0, HZCFG_MAGIC);
  for (uint8_t k = 0; k < 6; k++) {
    uint16_t x = *vals[k];
    eewrite(HZCFG_ADDR + k * 2, (uint8_t)(x & 0xFF));
    eewrite(HZCFG_ADDR + k * 2 + 1, (uint8_t)(x >> 8));
  }
#endif
}

void hzcfgLoad() {
#if USE_EEPROM
  if (EEPROM.read(0) != HZCFG_MAGIC) return;
  uint16_t *vals[6] = {&cfgMinHz, &cfgMaxHz, &cfgCamSpan,
                       &cfgMicSpan, &cfgTxtSpan, &cfgSpkSpan};
  for (uint8_t k = 0; k < 6; k++) {
    uint16_t x = (uint16_t)EEPROM.read(HZCFG_ADDR + k * 2)
               | (uint16_t)(EEPROM.read(HZCFG_ADDR + k * 2 + 1) << 8);
    if (x) *vals[k] = x;              // 0 = оставить значение по умолчанию
  }
  if (cfgMaxHz <= cfgMinHz + 100) cfgMaxHz = cfgMinHz + 100;
#endif
}

/* Применить строку "min,max,cam,mic,txt,spk" (из Cloud Studio через Linux):
 * парсим, клэмпим, сохраняем в EEPROM и сразу перезапускаем шину. */
void hzcfgApply(const char *s) {
  long v[6] = {0, 0, 0, 0, 0, 0}; uint8_t i = 0;
  for (; *s && i < 6; s++) {
    if (*s == ',') { if (v[i] || i) i++; continue; }
    if (*s < '0' || *s > '9') continue;
    v[i] = v[i] * 10 + (*s - '0');
    if (v[i] > 100000) v[i] = 100000;
  }
  if (v[0]) cfgMinHz = (uint16_t)(v[0] < 60 ? 60 : (v[0] > 1000 ? 1000 : v[0]));
  if (v[1]) cfgMaxHz = (uint16_t)(v[1] < 300 ? 300 : (v[1] > 4000 ? 4000 : v[1]));
  if (v[2] >= 0 && v[2] <= 1000) cfgCamSpan = (uint16_t)v[2];
  if (v[3] >= 0 && v[3] <= 1000) cfgMicSpan = (uint16_t)v[3];
  if (v[4] >= 0 && v[4] <= 1000) cfgTxtSpan = (uint16_t)v[4];
  if (v[5] >= 0 && v[5] <= 1000) cfgSpkSpan = (uint16_t)v[5];
  if (cfgMaxHz <= cfgMinHz + 100) cfgMaxHz = cfgMinHz + 100;
  if (genHz < cfgMinHz) genHz = cfgMinHz;
  if (genHz > cfgMaxHz) genHz = cfgMaxHz;
  hzcfgSave();
  broadcastGen();                     // пересчитать частоту немедленно
  txtBump(20);                        // нейроны «замечают» перенастройку
}

/* Вклад камеры 0..100: считаем объекты в val_b (YOLO-сводка).
 * Формат: "person 0.91, dog 0.77" — разделители ','/'!'/' '; пусто,
 * "объектов нет" или "no-video" (нет цифр) = 0. */
uint8_t camScore() {
  bool digits = false; uint8_t seps = 0;
  for (const char *p = val_b; *p; p++) {
    if (*p >= '0' && *p <= '9') digits = true;
    else if (*p == ',' || *p == '!' || *p == ';') seps++;
  }
  if (!digits) return 0;
  uint8_t obj = seps + 1; if (obj > 4) obj = 4;
  return obj * 25;                     // 25..100
}

/* Всплеск текст-активности: чат/свои реплики/облако */
void txtBump(uint8_t n) {
  int v = (int)txtLevel + n; if (v > 100) v = 100;
  txtLevel = (uint8_t)v;
}

/* ----------------------------- ДИНАМИК (v1.9) ---------------------------- */
/* Голос мозга: фраза из 2-4 посылок тона, построенная от текущей частоты
 * шины genHz (квинтовые ходы вверх). Неблокирующий программный меандр —
 * работает и без tone() (важно для Zephyr-ядра UNO Q).
 * Анти-заводка: если микрофон перегружен (динамик слишком близко / громко)
 * дольше MIC_HOT_MS — голос молчит VOICE_COOL_MS, петля размыкается.      */
void voiceSay(uint16_t hzBase, uint8_t tones) {
  if (!voiceOn) return;
  if (voxSteps || melLen) return;         // уже говорим — не перебиваем
  if (micHotSince && millis() - micHotSince > MIC_HOT_MS &&
      millis() - lastPhraseMs < VOICE_COOL_MS)
    return;                             // анти-заводка: микрофон перегружен
  if (hzBase < 150) hzBase = 150;
  if (hzBase > VOICE_TONE_MAX) hzBase = VOICE_TONE_MAX;
  toneHz = hzBase;
  voxSteps = tones ? tones : 3;
  voicePhase = true;
  tVoicePhase = millis();
  nextToneEdgeUs = micros();
  voxCount++;                           // ещё одна фраза в статистику VOX=
}

void voiceTick() {
  if (!voiceOn) {
    if (toneOut) { toneOut = false; digitalWrite(SPEAKER_PIN, LOW); }
    melLen = 0;
    return;
  }
  if (melLen) { melTick(); return; }      // v2.3: произносим слово нотами
  if (!voxSteps) {
    if (toneOut) { toneOut = false; digitalWrite(SPEAKER_PIN, LOW); }
    return;
  }
  if (voicePhase) {                     // посылка: программный меандр toneHz
    uint32_t halfUs = 500000UL / toneHz;
    if ((int32_t)(micros() - nextToneEdgeUs) >= 0) {
      toneOut = !toneOut;
      digitalWrite(SPEAKER_PIN, toneOut ? HIGH : LOW);
      nextToneEdgeUs += halfUs;
    }
    if (millis() - tVoicePhase >= VOICE_MS) {        // конец посылки
      voicePhase = false; tVoicePhase = millis();
      toneOut = false; digitalWrite(SPEAKER_PIN, LOW);
    }
  } else if (millis() - tVoicePhase >= VOICE_GAP_MS) { // конец паузы
    voxSteps--;
    if (voxSteps) {                     // следующая посылка — квинта вверх
      voicePhase = true; tVoicePhase = millis();
      toneHz = (uint16_t)(toneHz * 3 / 2);
      if (toneHz > VOICE_TONE_MAX + 900) toneHz = (uint16_t)(toneHz * 2 / 3);
      nextToneEdgeUs = micros();
    } else {
      lastPhraseMs = millis();          // фраза закончилась
    }
  }
}

/* --------------------- ПРОИЗНОШЕНИЕ СЛОВ (v2.3) -------------------------- */
/* Слово «проговаривается» динамиком D8 МЕЛОДИЕЙ: каждая буква 1..33 — своя
 * нота (250 + номер*24 Гц), 80 мс. Это и есть учатие произношения в скетче:
 * слово из текущего буфера сборки звучит целиком, как короткое «слово».
 * Неблокирующая очередь шагов (нота/пауза) поверх голосового движка.       */
void melStart() {
  if (voxSteps) { melLen = 0; return; }   // не перебивать фразу мотивации
  melIdx = 0; melTone = true; tMel = millis();
  if (mel[0].hz) toneHz = mel[0].hz;
  nextToneEdgeUs = micros();
}

void melTick() {
  if (melTone) {                          // нота: программный меандр
    uint16_t hz = mel[melIdx].hz;
    if (hz == 0) {                        // v2.14: кадр-пауза — тишина на D8
      if (toneOut) { toneOut = false; digitalWrite(SPEAKER_PIN, LOW); }
    } else {
      if (hz < 150) hz = 150;
      uint32_t halfUs = 500000UL / hz;
      if ((int32_t)(micros() - nextToneEdgeUs) >= 0) {
        toneOut = !toneOut;
        digitalWrite(SPEAKER_PIN, toneOut ? HIGH : LOW);
        nextToneEdgeUs += halfUs;
      }
    }
    if (millis() - tMel >= mel[melIdx].ms) {
      melTone = false; tMel = millis();
      toneOut = false; digitalWrite(SPEAKER_PIN, LOW);
    }
  } else if (millis() - tMel >= mel[melIdx].ms) {   // пауза кончилась
    melIdx++;
    if (melIdx >= melLen) { melLen = 0; lastPhraseMs = millis(); return; }
    melTone = true; tMel = millis();
    if (mel[melIdx].hz) toneHz = mel[melIdx].hz;
    nextToneEdgeUs = micros();
  }
}

/* Номер буквы по её 2 байтам UTF-8 (0 = не буква) */
uint8_t letterNumOf(const char *two) {
  for (uint8_t i = 0; i < 33; i++)
    if (RU33[i][0] == two[0] && RU33[i][1] == two[1]) return i + 1;
  return 0;
}

void voiceWord(const char *w) {
  if (!voiceOn || melLen) return;         // голос выключен или уже звучит слово
  for (uint16_t p = 0; w[p] && melLen < MEL_MAX - 2; p += 2) {
    uint8_t num = letterNumOf(w + p);
    if (!num) break;
    uint16_t hz = 250 + num * 24; if (hz > 1100) hz = 1100;
    mel[melLen].hz = hz;  mel[melLen].ms = 80;   melLen++;   // нота буквы
    mel[melLen].hz = 0;   mel[melLen].ms = 34;   melLen++;   // пауза
  }
  if (melLen) { mel[melLen - 1].ms = 130; melStart(); }    // хвост слова длиннее
}

/* --------------------- НЕЙРОСЕТЬ БУКВ (v2.3) ------------------------------ */
/* Перцептрон 10x36: на входах — состояние мозга (частота шины, звук, камера,
 * текст, спайки, предыдущий класс, длина слова/фразы, флаг «после запятой»),
 * на выходах — 33 буквы + ПРОБЕЛ + ЗАПЯТАЯ + ТОЧКА. Победитель — аргмакс с
 * 20% исследованием («лепет»: учителю есть что оценивать). Выбор ВСЕГДА
 * делает сама сеть; LLM-ядро (ключ "teach" = +1/-1) только подкрепляет
 * решения завершённой фразы — УЧИТ, а не выбирает за мозг.
 * Веса — int8, хранятся в EEPROM (переживают перезагрузку).                */
static uint32_t g_lcg = 0x2F6E2B1;
static uint32_t lcgNext() { g_lcg = g_lcg * 1664525u + 1013904223u; return g_lcg; }
static int8_t netRnd(int8_t lim) { return (int8_t)(lcgNext() % (2 * (long)lim + 1)) - lim; }

void netInitWeights() {
  for (uint8_t o = 0; o < NET_OUT; o++)
    for (uint8_t i = 0; i < NET_IN; i++)
      netW[o][i] = netRnd(6);
  /* приоры «речевой механики» — чтобы с первого включения лепет был похож
   * на речь: буквы охотнее знаков, пробел — на длинном слове, точка — на
   * длинной фразе, после запятой — пробел */
  for (uint8_t o = 0; o < 33; o++) {
    netW[o][0] += 14;                             // bias: буквы базово
    if (RU_VOW[o]) netW[o][0] += 6;               // гласные чуть чаще
    netW[o][7] -= 3;                              // длинное слово — меньше букв
  }
  netW[CL_SPACE][0] += 10; netW[CL_SPACE][7] += 30; netW[CL_SPACE][9] += 25;
  netW[CL_COMMA][0] += 2;  netW[CL_COMMA][7] += 12; netW[CL_COMMA][8] += 15;
  netW[CL_DOT][0]   += 2;  netW[CL_DOT][8]   += 40;
  netDirty = true;
}

/* v2.67: ЗАПИСЬ В EEPROM ПО ЧУТЬ-ЧУТЬ. На UNO Q EEPROM — эмуляция во
 * flash: каждая запись байта может стоить миллисекунды-десятки мс. Раньше
 * сохранение весов писало сотни байт ПОДРЯД в loop() — скетч замирал на
 * секунды, сводки по мосту не шли (чип «мост: молчит/ждёт скетч»), D4/D6
 * запинались. Теперь netSave()/wordsSave() только ставят запись в очередь,
 * а eePumpTick() в loop() пишет не больше EE_STEP изменённых байт за проход
 * (признак «веса записаны» — последним, после данных). */
#define EE_STEP 2
uint8_t  eePend = 0;          // 1 — веса букв, 2 — веса слов
uint8_t  eeWhat = 0;          // что пишем сейчас
uint16_t eeCur = 0;           // номер байта в текущей записи
void netSave() {
#if USE_EEPROM
  if (!netDirty) return;
  eePend |= 1;
#endif
  netDirty = false;
}

bool netLoad() {
#if USE_EEPROM
  if (EEPROM.read(NET_MAGIC_ADDR) != NET_MAGIC) return false;
  uint8_t *p = (uint8_t *)netW;
  for (uint16_t k = 0; k < NET_OUT * NET_IN; k++) p[k] = EEPROM.read(NET_WADDR + k);
  return true;
#else
  return false;
#endif
}

/* Входы сети 0..100 из текущего состояния мозга */
void netInputs(int8_t *x) {
  uint16_t span = (cfgMaxHz > cfgMinHz) ? (cfgMaxHz - cfgMinHz) : 1;
  int32_t g = ((int32_t)genHz - (int32_t)cfgMinHz) * 100 / span;
  if (g < 0) g = 0;
  if (g > 100) g = 100;
  x[0] = 100;                               // смещение
  x[1] = (int8_t)g;                         // частота шины (GEN)
  x[2] = (int8_t)micLevel;                  // звук (D12/D13)
  x[3] = (int8_t)camScore();                // камера (val_b/YOLO)
  x[4] = (int8_t)txtLevel;                  // текст-канал
  x[5] = (int8_t)spkLvlLast;                // спайки нейронов
  x[6] = (int8_t)(lastClass == 255 ? 0 : (int32_t)lastClass * 100 / 35);
  x[7] = (int8_t)((int32_t)genWordLen / 2 * 100 / WORD_MAX);   // букв в слове
  x[8] = (int8_t)((int32_t)genSentChars * 100 / SENT_MAX);     // длина фразы
  x[9] = afterPunct ? 100 : 0;              // предыдущий символ — запятая
}

uint8_t netPick(const int8_t *x) {
  int32_t best = -2000000000L; uint8_t bo = 0;
  for (uint8_t o = 0; o < NET_OUT; o++) {
    int32_t acc = 0;
    for (uint8_t i = 0; i < NET_IN; i++) acc += (int32_t)netW[o][i] * x[i];
    int32_t act = (acc >> 6) + netRnd(2);   // лёгкий дрейф = «живость»
    if (act > best) { best = act; bo = o; }
  }
  if ((lcgNext() % 100) < 5) bo = lcgNext() % 33;    // v2.85: было 20% — чистый лепет давал «ИЧИИЕИФИИЪ»;
                                                     // оставляем 5% исследования, остальное — сеть
  return bo;
}

/* ------------- СЛОВОГЕНЕРАТОР (v2.26): СЛОВА ИЗ СЛОВАРЯ ------------------
 * Слова выбирает САМА сеть: у каждого слова вес wordW (учитель
 * подкрепляет) и контекстные веса wordCtx (входы: bias, текст-канал,
 * звук, спайки) — слово «к месту» звучит чаще. Словарь — 64 частых
 * русских слова ЗАГЛАВНЫМИ (тот же алфавит, что у буквенной сети).
 * Веса — в EEPROM (после весов букв, 460+). 15% — исследование:
 * пробуем редкие слова, учителю есть что оценивать.                    */
#define WD_N        64      // слов в словаре
#define WD_MAXL     8       // букв в слове словаря (2 байта UTF-8 + NUL)
#define WD_MODE_PCT 92      // v2.85: было 70 — 30% чистого буквенного лепета
                            // давали бессвязные «слова». Теперь почти всегда
                            // словарь; буквенная сеть остаётся для обучения.
#define WORD_MAGIC_ADDR 455 // EEPROM: признак записанных весов слов
#define WORD_WADDR      460 // EEPROM: wordW[WD_N] + wordCtx[WD_N][4]
#define WORD_MAGIC      0x5C

const char WDICT[WD_N][WD_MAXL * 2 + 1] = {
  "ПРИВЕТ","КАК","ДЕЛА","ЧТО","КТО","ГДЕ","КОГДА","ПОЧЕМУ","Я","ТЫ","МЫ",
  "ОНИ","ХОЧУ","ЗНАЮ","ДУМАЮ","ВИЖУ","СЛЫШУ","ГОВОРЮ","ПОНЯЛ","СПАСИБО",
  "ИЗВИНИ","ХОРОШО","ПЛОХО","МОЖНО","НУЖНО","НАДО","ДАВАЙ","ДА","НЕТ",
  "ТУТ","ТАМ","СЕЙЧАС","ПОТОМ","ВСЕГДА","НИКОГДА","УЧУСЬ","РАСТУ","ДЕНЬ",
  "НОЧЬ","ВРЕМЯ","ДОМ","МИР","ДРУГ","МОЗГ","НЕЙРОН","ПАМЯТЬ","МЫСЛЬ",
  "СЛОВО","СИЛА","ЖИЗНЬ","ЛЮДИ","ЛЮБЛЮ","ПОМОГИ","СКАЖИ","ЖДУ","ИЩУ",
  "НАШЁЛ","РАД","ЖАЛЬ","ВЕРЮ","ЖИВУ","БУДУ","ЗДЕСЬ","ЕЩЁ"
};

int8_t   wordW[WD_N];               // вес слова (подкрепляет учитель)
int8_t   wordCtx[WD_N][4];          // контекст: bias/текст/звук/спайки
bool     wordsDirty = false;
uint32_t wordsSaveAt = 0;
uint8_t  dictCur = 255;             // текущее словарное слово (255 = лепет)
uint8_t  dictPos = 0;               // сколько букв слова уже вышло
uint8_t  lastWordIdx = 255;         // последнее слово (ждёт оценки учителя)
bool     wordDecFresh = false;
uint32_t wordsPicked = 0;           // сколько слов выбрано из словаря

/* v2.27: СЛОВО ОТ МОЗГА (большой словарь ru_top.json / облако). Мозг сам
 * выбирает слово (перекос к частым) и присылает RPC word_push. Слово
 * произносится обычным конвейером (dictLetterTick): только там буквы
 * получают решения учителя, теги нейронам и SAY=. Встроенные 64 слов —
 * резерв (мост молчит).
 * v2.34: ПАМЯТЬ ПЛАТЫ НА КАЖДОЕ СЛОВО — кольцевая ОЧЕРЕДЬ. Мозг шлёт
 * слова раз в 0.5 с, а конвейер произносит слово за ~0.4-1.5 с: старый
 * слот на одно слово (wordPushFresh) терял всё, кроме последнего.
 * Теперь КАЖДОЕ слово ждёт своей очереди в wordQ и произносится по
 * порядку; при переполнении слово честно считается потерянным
 * (wordQDrop). Глубину очереди и счётчики мозг видит RPC word_q. */
char     wordPush[WORD_MAX * 2 + 2];   // слово, взятое из очереди (стойло)
char     wordCur[WORD_MAX * 2 + 2];    // слово, которое произносим сейчас
uint8_t  dictSrc = 0;                  // 0 = WDICT[dictCur], 1 = wordCur
uint32_t wordsPushed = 0;              // сколько слов пришло от мозга
#define WQ_N 20                        // слов в очереди платы (память)
char     wordQ[WQ_N][WORD_MAX * 2 + 2];
uint8_t  wordQHead = 0;                // куда писать следующее слово
uint8_t  wordQTail = 0;                // откуда читать следующее слово
uint8_t  wordQCnt = 0;                 // сколько слов ждёт очереди
uint32_t wordQDrop = 0;                // потеряно при переполнении (честно)

int8_t wdictFind(const char *w) {
  for (uint8_t i = 0; i < WD_N; i++)
    if (strcmp(WDICT[i], w) == 0) return (int8_t)i;
  return -1;
}

void rpcWordPush(String w) {
  /* строка от мозга: ЗАГЛАВНЫЕ кириллические буквы (2 байта UTF-8);
   * каждую пару проверяем по RU33 — мусор от шины не произносим.
   * v2.34: слово встаёт в ОЧЕРЕДЬ (память платы на каждое слово).
   * v2.38: ОДИНОЧНЫЙ ЗНАК ПРЕПИНАНИЯ (",", ".", "!", "?") — тоже запись
   * словаря мозга: знак в ту же очередь, механика знаков в letterTick
   * (boardMarkTick). СЕТЬ БУКВ НЕ ТРОНУТА (10x36, как была). */
  char buf[WORD_MAX * 2 + 4];
  strlcpy(buf, w.c_str(), sizeof(buf));
  utf8Fix(buf);
  if (buf[0] && !buf[1] && strchr(",.!?", buf[0])) {   // v2.38: знак
    if (wordQCnt >= WQ_N) {               // очередь полна — честно
      wordQDrop++;
      return;
    }
    wordQ[wordQHead][0] = buf[0];
    wordQ[wordQHead][1] = 0;
    wordQHead = (uint8_t)((wordQHead + 1) % WQ_N);
    wordQCnt++;
    wordsPushed++;
    HUB_OUT.print("[GEN] знак от мозга (в очереди ");
    HUB_OUT.print(wordQCnt);
    HUB_OUT.print("): "); HUB_OUT.println(buf);
    return;
  }
  uint8_t n = 0;
  for (uint16_t p = 0; buf[p] && buf[p + 1] && n < WORD_MAX; p += 2) {
    if (!letterNumOf(buf + p)) return;    // не кириллица — слово не берём
    n++;
  }
  if (!n) return;
  if (wordQCnt >= WQ_N) {               // очередь полна — честно, без вранья
    wordQDrop++;
    return;
  }
  strlcpy(wordQ[wordQHead], buf, sizeof(wordQ[0]));
  wordQHead = (uint8_t)((wordQHead + 1) % WQ_N);
  wordQCnt++;
  wordsPushed++;
  HUB_OUT.print("[GEN] слово от мозга (в очереди ");
  HUB_OUT.print(wordQCnt);
  HUB_OUT.print("): "); HUB_OUT.println(buf);
}

/* v2.34: СОСТОЯНИЕ ОЧЕРЕДИ СЛОВ для мозга — RPC word_q:
 * "q=<ждёт в очереди>;p=<всего пришло>;d=<потеряно при переполнении>".
 * Обработчик мгновенный (только собирает строку). */
String rpcWordQ() {
  return String("q=") + wordQCnt + ";p=" + wordsPushed + ";d=" + wordQDrop;
}

/* v2.28: НАЗНАЧЕНИЕ НОМЕРОВ НЕЙРОНАМ (RPC neuro_assign -> отчёт строкой).
 * Слоты 0..NEURONS-1 опрашиваются; если слот МОЛЧИТ — в общий вызов
 * (адрес 0) уходит "SETID;<n>": её берёт только плата БЕЗ номера
 * (neuron_node v2.6, EEPROM). Через 400 мс слот перепрашивается.
 * ВНИМАНИЕ: пустых плат на шине должно быть НЕ БОЛЬШЕ ОДНОЙ — иначе
 * несколько возьмут один номер (в отчёте будет виден мусор/коллизия).
 * v2.33: НЕБЛОКИРУЮЩЕЕ ИСПОЛНЕНИЕ (прошлая причина таймаутов всего
 * RPC-канала: word_push/cloud_buf_set/chat_stim/say_wave падали в окно
 * блокировки). Обработчик НЕ ждёт — только запускает машину состояний
 * (asgBusy) и мгновенно отвечает "started". Шаги делает
 * neuroAssignTick() из loop(): одна фаза за итерацию, БЕЗ delay().
 * Прогресс/отчёт — RPC neuro_assign_poll ("p:<готово>;<busy|done>;<rep>"). */
uint8_t  asgIdx = 0;          // текущий слот
uint8_t  asgPhase = 0;        // 0 = опрос слота, 1 = SETID послан, ждём
bool     asgBusy = false;     // машина назначений активна
uint32_t tAsg = 0;            // таймер фазы ожидания (400 мс после SETID)
String   asgRep = "";         // накопленный отчёт
uint8_t  asgAlive = 0, asgAssigned = 0;

String rpcNeuroAssign() {
  if (asgBusy) {
    return String("busy:") + asgIdx + "/" + NEURONS;
  }
  asgIdx = 0; asgPhase = 0; asgBusy = true;
  asgRep = ""; asgAlive = 0; asgAssigned = 0;
  HUB_OUT.println("[NET] neuro_assign: запущено (неблокирующе, v2.33)");
  return String("started");
}

String rpcNeuroAssignPoll() {
  return String("p:") + asgIdx + ";" + (asgBusy ? "busy" : "done") + ";" +
         asgRep;
}

void neuroAssignTick() {
  if (!asgBusy) return;
  if (asgPhase == 1) {
    if (millis() - tAsg < 400) return;      // плате дать перерегистрироваться
#if LINK_SW_WIRE
    uint8_t addr = I2C_BASE_ADDR + asgIdx;
    uint8_t got = NeuroBus.requestFrom(addr, (uint8_t)2);
    while (NeuroBus.available()) NeuroBus.read();
    if (got) { asgAssigned++; asgAlive++;
               asgRep += String(asgIdx) + ":НАЗНАЧЕН "; }
    else     { asgRep += String(asgIdx) + ":пусто "; }
#else
    /* серийный режим: канал адресный, SETID ушёл адресно — слот считается
     * назначенным (отчёт "ser"); точную живость покажет обычный опрос */
    asgAssigned++; asgAlive++;
    asgRep += String(asgIdx) + ":ser ";
#endif
    asgPhase = 0;
    asgIdx++;
    if (asgIdx >= NEURONS) {                // всё — печатаем итог
      asgBusy = false;
      HUB_OUT.print("[NET] neuro_assign: живых/назначено ");
      HUB_OUT.print(asgAlive); HUB_OUT.print("/");
      HUB_OUT.print(asgAssigned); HUB_OUT.print(" — ");
      HUB_OUT.println(asgRep);
    }
    return;
  }
  /* фаза 0: опросить слот; живой — пометить, молчащий — послать SETID */
  if (asgIdx >= NEURONS) { asgBusy = false; return; }
#if LINK_SW_WIRE
  uint8_t addr = I2C_BASE_ADDR + asgIdx;
  uint8_t got = NeuroBus.requestFrom(addr, (uint8_t)2);
  while (NeuroBus.available()) NeuroBus.read();
  if (got) { asgAlive++; asgRep += String(asgIdx) + ":занят "; asgIdx++; return; }
  String cmd = "SETID;" + String(asgIdx);   // ОБЩИЙ ВЫЗОВ (адрес 0)
  NeuroBus.beginTransmission(0x00);
  for (uint8_t k = 0; k < cmd.length(); k++)
    NeuroBus.write((uint8_t)cmd[k]);
  NeuroBus.endTransmission();
#else
  /* серийный режим: нейрон с пустым номером берёт "SETID;<n>" через
   * мультиплексор — канал адресуется индивидуально, конфликтов нет */
  setMux(asgIdx);
  NeuroSer.println("SETID;" + String(asgIdx));
#endif
  asgPhase = 1;                             // ждём 400 мс БЕЗ delay()
  tAsg = millis();
}

/* v2.29: СБРОС НОМЕРОВ (RPC neuro_reset -> отчёт строкой). Всем платам в
 * ОБЩИЙ ВЫЗОВ (адрес 0) уходит "CLR_ID": прошивка neuron_node v2.7 стирает
 * номер из EEPROM и снова слушает общий вызов («сирота», быстрое мигание
 * LED). Ручные платы (NEURON_ID 0..11 в коде) команду игнорируют. После
 * сброса подключайте платы ПО ОДНОЙ и запускайте neuro_assign («нейроны»). */
String rpcNeuroReset() {
#if LINK_SW_WIRE
  NeuroBus.beginTransmission(0x00);              // ОБЩИЙ ВЫЗОВ — слышат все
  NeuroBus.write((const uint8_t *)"CLR_ID", (uint8_t)6);
  NeuroBus.endTransmission();
  /* v2.33: delay(50) убран — обработчик Bridge обязан быть мгновенным;
   * I2C-передача сама завершается в endTransmission() */
#else
  /* серийный режим: "CLR_ID" через мультиплексор в каждый канал */
  for (uint8_t n = 0; n < NEURONS; n++) {
    setMux(n);
    NeuroSer.println("CLR_ID");
    delay(30);
  }
#endif
  HUB_OUT.println("[NET] neuro_reset: CLR_ID отправлен всем платам (общий вызов)");
  return "CLR_ID отправлен всем платам; теперь подключайте платы ПО ОДНОЙ "
         "и запускайте назначение («нейроны»)";
}

/* ============================================================================
 * v2.30: ПРИЁМНИК КАДРОВ КАМЕРЫ ПО UART (ESP32-CAM -> UNO Q, ПО ПРОВОДУ)
 * Камера (sketch/esp32cam_uart v1.0) шлёт JPEG-кадры форматом «буфера»:
 *   A5 5C | тип (1) | seq (1) | len (2, LE) | crc16/XMODEM (2, LE) | payload
 * Приём НЕБЛОКИРУЮЩИЙ: camUartTick() вызывается из loop() каждый раз,
 *   парсер-автомат пересинхронизируется по магии, кадры с неверным CRC
 *   отбрасываются (счётчик camBad) — поток переживает шум линии.
 * Целый JPEG хранится в camBuf (последний кадр) и отдаётся мозгу КУСКАМИ:
 *   RPC cam_frame_info -> "len=..;seq=..;ok=..;bad=..;age_ms=..;baud=.."
 *   RPC cam_chunk("seq:off") -> base64-кусок ("" — кадр уже сменился:
 *   мозг перечитает info). Лимит сообщения моста 8 КБ не нарушается.
 * ПОДКЛЮЧЕНИЕ: TX ESP32-CAM (GPIO13) -> RX Serial1 (D0), GND общий;
 *   SD-карту из ESP32-CAM вынуть (её пины 13/14). Скорость = CAM_BAUD
 *   скетча камеры. При LINK_SW_WIRE 0 Serial1 может быть занят нейронами
 *   (запасной вариант) — тогда камеру вешать на другой UART. */
#define CAMRX          Serial1   // аппаратный UART платы (D0/D1)
#define CAMRX_BAUD     460800    // = CAM_BAUD скетча камеры
#define CAMRX_BUF      20480     // v2.89.2: 2 буфера по 20 КБ = те же 40 КБ памяти, что до v2.88
                                 // (в v2.88 было 2×40 КБ — скетч мог не поместиться и не стартовать);
                                 // JPEG QVGA q12 — 6…15 КБ, кадр больше 20 КБ отбрасывается
#define CAMRX_CHUNK    768       // байт в base64-куске RPC cam_chunk

static uint8_t  camBuf[CAMRX_BUF]; // последний целый кадр
static uint8_t  camRx[CAMRX_BUF];  // v2.88: приём идёт сюда; в camBuf — только целый JPEG (20 КБ)
#define CAMVIS_MAX     1200      // v2.88: JSON зрения камеры (тип 0x03)
static char     camVis[CAMVIS_MAX] = "";
static uint32_t camVisMs = 0, camVisN = 0;
static char     camVote[320] = ""; // v2.88: JSON голоса камеры (тип 0x04)
static uint32_t camVoteN = 0;
static uint16_t camLen = 0;        // его длина
static uint8_t  camFrameSeq = 0;   // seq последнего целого кадра
static uint32_t camLastMs = 0;     // когда кадр положили
static uint32_t camOk = 0, camBad = 0;          // счётчики целых/битых
static volatile bool camCopying = false;   // v2.94.1: кадр копируется в camBuf
static volatile uint32_t camGen = 0;       // v2.94.1: счётчик смен кадра (чётный — кадр целый)
static uint32_t camBytes = 0;      // v2.93: сколько байт пришло по UART вообще (0 = провод/питание)
static uint32_t camByteMs = 0;     // v2.93: когда пришёл последний байт
static uint32_t camLost = 0;       // v2.93: пакеты, оборванные паузой (переполнение приёмника)
static uint8_t  camPkt[8];         // заголовок принимаемого кадра
static uint8_t  camPktGot = 0;
static uint16_t camPktLen = 0, camPktGotData = 0;
static uint8_t  camState = 0;      // 0=ищем A5, 1=ждём 5C, 2=заголовок, 3=payload

/* CRC16/XMODEM (полином 0x1021, старт 0) — та же формула, что у камеры */
static uint16_t camCrc16(const uint8_t *d, uint16_t n) {
  uint16_t crc = 0;
  while (n--) {
    crc ^= (uint16_t)(*d++) << 8;
    for (uint8_t k = 0; k < 8; k++)
      crc = (crc & 0x8000) ? (uint16_t)((crc << 1) ^ 0x1021) : (uint16_t)(crc << 1);
  }
  return crc;
}

/* base64-кодер: кадр уезжает кусками по CAMRX_CHUNK байт -> 1024 символа */
static const char CAMB64[] =
  "ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz0123456789+/";

static String camB64(const uint8_t *d, int n) {
  String s;
  s.reserve(((n + 2) / 3) * 4);
  int i = 0;
  while (i + 2 < n) {
    uint32_t v = ((uint32_t)d[i] << 16) | ((uint32_t)d[i + 1] << 8) | d[i + 2];
    i += 3;
    s += CAMB64[(v >> 18) & 63];
    s += CAMB64[(v >> 12) & 63];
    s += CAMB64[(v >> 6) & 63];
    s += CAMB64[v & 63];
  }
  if (i < n) {                            // хвост 1-2 байта с добивкой '='
    uint32_t v = (uint32_t)d[i] << 16;
    if (i + 1 < n) v |= (uint32_t)d[i + 1] << 8;
    s += CAMB64[(v >> 18) & 63];
    s += CAMB64[(v >> 12) & 63];
    s += (i + 1 < n) ? CAMB64[(v >> 6) & 63] : '=';
    s += '=';
  }
  return s;
}

/* Неблокирующий приём байтов камеры — вызывать из loop() каждую итерацию */
void camUartTick() {
  /* v2.93: пакет оборвался (байты потеряны, пока loop был занят) — не ждём
   * его вечно, иначе съедим заголовок следующего кадра и испортим и его */
  if (camState >= 2 && (uint32_t)(millis() - camByteMs) > 60) { camState = 0; camLost++; }
  while (CAMRX.available()) {
    uint8_t b = (uint8_t)CAMRX.read();
    camBytes++; camByteMs = millis();
    if (camState == 0) {                  // сканируем магию A5 5C
      if (b == 0xA5) camState = 1;
    } else if (camState == 1) {
      if (b == 0x5C) { camState = 2; camPktGot = 0; }
      else camState = (b == 0xA5) ? 1 : 0;
    } else if (camState == 2) {           // добираем заголовок (ещё 6 байт)
      camPkt[camPktGot++] = b;
      if (camPktGot >= 8) {
        camPktLen = (uint16_t)camPkt[4] | ((uint16_t)camPkt[5] << 8);
        if (camPktLen == 0 || camPktLen > CAMRX_BUF) {
          camState = 0;
          camBad++;
        } else {
          camState = 3;
          camPktGotData = 0;
        }
      }
    } else {                              // payload кадра/статуса/зрения/голоса
      camRx[camPktGotData++] = b;
      if (camPktGotData >= camPktLen) {
        camState = 0;
        uint16_t crc = camCrc16(camRx, camPktLen);
        uint16_t want = (uint16_t)camPkt[6] | (uint16_t)((uint16_t)camPkt[7] << 8);
        if (crc != want) { camBad++; continue; }
        uint8_t typ = camPkt[2];
        if (typ == 0x01) {                // JPEG-кадр — целиком в camBuf
          if (camRx[0] == 0xFF && camRx[1] == 0xD8) {
            camCopying = true;                // v2.94.1: поток моста не читает кадр, пока копируем
            camGen++;
            memcpy(camBuf, camRx, camPktLen);
            camLen = camPktLen;
            camFrameSeq = camPkt[3];
            camGen++;
            camCopying = false;
            camLastMs = millis();
            camOk++;
          } else camBad++;                // не JPEG — в мусор
        } else if (typ == 0x03 && camPktLen < CAMVIS_MAX) {   // v2.88: зрение
          memcpy(camVis, camRx, camPktLen);
          camVis[camPktLen] = 0;
          camVisMs = millis();
          camVisN++;
        } else if (typ == 0x04 && camPktLen < sizeof(camVote)) { // v2.88: голос
          memcpy(camVote, camRx, camPktLen);
          camVote[camPktLen] = 0;
          camVoteN++;
        } else if (typ == 0x02) {         // текстовый статус камеры
          if (camPktLen < CAMRX_BUF) camRx[camPktLen] = 0;
          HUB_OUT.print("[CAM] ");
          HUB_OUT.println((const char *)camRx);
        }
      }
    }
  }
}

/* RPC cam_frame_info: параметры последнего кадра + счётчики (для мозга) */
String rpcCamFrameInfo() {
  if (!camLen)
    return "len=0;ok=" + String(camOk) + ";bad=" + String(camBad) +
           ";bytes=" + String(camBytes) + ";lost=" + String(camLost) +
           ";baud=" + String(CAMRX_BAUD);
  return "len=" + String(camLen) + ";seq=" + String(camFrameSeq) +
         ";ok=" + String(camOk) + ";bad=" + String(camBad) +
         ";age_ms=" + String(millis() - camLastMs) +
         ";baud=" + String(CAMRX_BAUD) +
         ";bytes=" + String(camBytes) + ";lost=" + String(camLost);
}

/* RPC cam_chunk("seq:off"): base64-кусок кадра; "" — кадр уже сменился
 * или аргумент кривой: мозг перечитает cam_frame_info и начнёт заново */
/* v2.88: КАМЕРА С НЕЙРОСЕТЬЮ (esp32cam_tflite) — слова выбираются вместе.
 * cam_vis()          -> "age_ms=N|{json зрения}" ("" — камера не присылала)
 * cam_vote("id|ф1|ф2|...") -> камере уходит строка V..., ответ — в cam_vote_res
 * cam_vote_res()     -> последний JSON голоса камеры ("" — ещё нет)
 * cam_say("фраза")   -> камере уходит W...: она учит слова со своей сценой */
/* ---------------- v2.94: VR3 — программный UART 9600 на D12/D13 ---------------- */
static volatile uint8_t  vrRing[256];
static volatile uint8_t  vrHead = 0, vrTail = 0;
static volatile uint32_t vrBytes = 0, vrErr = 0;
static uint8_t  vrFr[40];           // кадр AA | L | cmd | data | 0A (без AA и L)
static uint8_t  vrFrLen = 0, vrFrGot = 0, vrSt = 0;
static uint32_t vrFrMs = 0, vrFrames = 0;
static char     vrOut[600];         // готовые кадры hex через ';' (забирает vr_read)

static inline void vrWaitUntil(uint32_t t) { while ((int32_t)(micros() - t) < 0) {} }

void vrRxIsr() {
  if (digitalRead(VR_RX_PIN) != LOW) return;       // отложенный фронт внутри байта — не старт
  uint32_t t0 = micros();
  uint8_t b = 0;
  for (uint8_t i = 0; i < 8; i++) {                // середины бит: 1.5, 2.5 … 8.5 бита
    vrWaitUntil(t0 + VR_BIT_US + VR_BIT_US / 2 + (uint32_t)i * VR_BIT_US);
    if (digitalRead(VR_RX_PIN) == HIGH) b |= (uint8_t)(1u << i);
  }
  vrWaitUntil(t0 + 9u * VR_BIT_US + VR_BIT_US / 2);
  if (digitalRead(VR_RX_PIN) != HIGH) { vrErr++; return; }   // нет стоп-бита
  uint8_t n = (uint8_t)(vrHead + 1);
  if (n != vrTail) { vrRing[vrHead] = b; vrHead = n; }
  vrBytes++;
}

static void vrWriteByte(uint8_t b) {
  uint32_t t0 = micros();
  digitalWrite(VR_TX_PIN, LOW);
  vrWaitUntil(t0 + VR_BIT_US);
  for (uint8_t i = 0; i < 8; i++) {
    digitalWrite(VR_TX_PIN, ((b >> i) & 1) ? HIGH : LOW);
    vrWaitUntil(t0 + (uint32_t)(i + 2) * VR_BIT_US);
  }
  digitalWrite(VR_TX_PIN, HIGH);
  vrWaitUntil(t0 + 10u * VR_BIT_US);
}

static void vrFrameDone() {
  char hx[3 * 40 + 2];
  uint8_t k = 0;
  static const char H[] = "0123456789ABCDEF";
  for (uint8_t i = 0; i + 1 < vrFrGot && k + 3 < sizeof(hx); i++) {   // без хвоста 0A
    hx[k++] = H[vrFr[i] >> 4];
    hx[k++] = H[vrFr[i] & 15];
  }
  hx[k] = 0;
  size_t ol = strlen(vrOut);
  if (ol + k + 2 >= sizeof(vrOut)) { vrOut[0] = 0; ol = 0; }          // никто не забирал — с начала
  memcpy(vrOut + ol, hx, k);
  vrOut[ol + k] = ';';
  vrOut[ol + k + 1] = 0;
  vrFrames++;
}

void vrTick() {
  if (vrSt && (uint32_t)(millis() - vrFrMs) > 200) vrSt = 0;         // оборванный кадр
  while (vrTail != vrHead) {
    uint8_t b = vrRing[vrTail];
    vrTail = (uint8_t)(vrTail + 1);
    vrFrMs = millis();
    if (vrSt == 0) { if (b == 0xAA) vrSt = 1; }
    else if (vrSt == 1) {
      if (b < 2 || b > sizeof(vrFr)) { vrSt = (b == 0xAA) ? 1 : 0; continue; }
      vrFrLen = b; vrFrGot = 0; vrSt = 2;
    } else {
      vrFr[vrFrGot++] = b;
      if (vrFrGot >= vrFrLen) {
        if (b == 0x0A) vrFrameDone(); else vrErr++;
        vrSt = 0;
      }
    }
  }
}

/* RPC vr_enable("1"/"0") — включить/выключить приём VR3 на D12/D13 */
static bool vrOn = false;
String rpcVrEnable(String a) {
  bool want = a.length() && a[0] == '1';
  if (want == vrOn) return vrOn ? "on" : "off";
  if (want) {
    int irq = digitalPinToInterrupt(VR_RX_PIN);
    if (irq < 0) return "no-irq";
    pinMode(VR_TX_PIN, OUTPUT);
    digitalWrite(VR_TX_PIN, HIGH);
    pinMode(VR_RX_PIN, INPUT_PULLUP);
    attachInterrupt(irq, vrRxIsr, FALLING);
    vrOn = true;
    return "on";
  }
  detachInterrupt(digitalPinToInterrupt(VR_RX_PIN));
  vrOn = false;
  return "off";
}

/* RPC vr_read -> "b=<байт>;e=<ошибок>;f=<кадров>|HEX;HEX;" (кадры: cmd+data) */
String rpcVrRead() {
  vrTick();                          // v2.94.4: разбор кадров — здесь, в потоке моста
  String r = "b=" + String(vrBytes) + ";e=" + String(vrErr) + ";f=" + String(vrFrames) + "|" + String(vrOut);
  vrOut[0] = 0;
  return r;
}

/* RPC vr_send("HEX") — cmd+data; плата сама добавит AA, длину и 0A */
String rpcVrSend(String hex) {
  if (!vrOn) return "off";
  uint8_t buf[40];
  uint8_t n = 0;
  hex.trim();
  for (unsigned i = 0; i + 1 < hex.length() && n < sizeof(buf); i += 2) {
    char a = hex[i], c = hex[i + 1];
    auto v = [](char x) -> int { return x >= '0' && x <= '9' ? x - '0' : x >= 'a' && x <= 'f' ? x - 'a' + 10 : x >= 'A' && x <= 'F' ? x - 'A' + 10 : -1; };
    int hi = v(a), lo = v(c);
    if (hi < 0 || lo < 0) return "bad hex";
    buf[n++] = (uint8_t)(hi * 16 + lo);
  }
  if (!n) return "empty";
  vrWriteByte(0xAA);
  vrWriteByte((uint8_t)(n + 1));   // длина = cmd + data + 0A
  for (uint8_t i = 0; i < n; i++) vrWriteByte(buf[i]);
  vrWriteByte(0x0A);
  return "ok";
}

static void camLine(char cmd, String arg) {
  arg.replace("\n", " ");
  arg.replace("\r", " ");
  if (arg.length() > 700) arg = arg.substring(0, 700);
  CAMRX.print(cmd);
  CAMRX.print(arg);
  CAMRX.print('\n');
}

String rpcCamVis() {
  if (!camVisN) return "";
  return "age_ms=" + String(millis() - camVisMs) + "|" + String(camVis);
}

String rpcCamVote(String arg) {
  camVote[0] = 0;
  camLine('V', arg);
  return "ok";
}

String rpcCamVoteRes() { return String(camVote); }

String rpcCamSay(String arg) {
  camLine('W', arg);
  return "ok";
}

String rpcCamChunk(String arg) {
  int col = arg.indexOf(':');
  if (col <= 0) return "";
  long seq = arg.substring(0, col).toInt();
  long off = arg.substring(col + 1).toInt();
  uint32_t g0 = camGen;                       // v2.94.1: вызывается из потока моста
  if (camCopying || (g0 & 1) || seq != (long)camFrameSeq || camLen == 0 ||
      off < 0 || off >= (long)camLen) return "";
  int n = (int)camLen - (int)off;
  if (n > CAMRX_CHUNK) n = CAMRX_CHUNK;
  String r = camB64(camBuf + off, n);
  if (camGen != g0 || camCopying) return "";  // кадр сменился, пока читали — заново
  return r;
}

void wordInputs(int8_t *x) {
  x[0] = 100;                       // смещение
  x[1] = (int8_t)txtLevel;          // текст-канал (чат/свои слова/облако)
  x[2] = (int8_t)micLevel;          // звук
  x[3] = (int8_t)spkLvlLast;        // спайки нейронов
}

uint8_t wordPick(const int8_t *x) {
  int32_t best = -2000000000L; uint8_t bo = 0;
  for (uint8_t i = 0; i < WD_N; i++) {
    int32_t acc = (int32_t)wordW[i] * 4;
    for (uint8_t k = 0; k < 4; k++) acc += (int32_t)wordCtx[i][k] * x[k];
    acc = (acc >> 6) + (int32_t)(lcgNext() % 13) - 6;   // живость выбора
    if (acc > best) { best = acc; bo = i; }
  }
  if ((lcgNext() % 100) < 15) bo = (uint8_t)(lcgNext() % WD_N); // исследование
  return bo;
}

/* Учитель оценил фразу — подкрепляем и выбор последнего слова */
void wordTeach(int8_t reward) {
  if (!wordDecFresh || lastWordIdx >= WD_N) return;
  int32_t w = (int32_t)wordW[lastWordIdx] + (int32_t)reward * 2 * learningScale;
  if (w > 40) w = 40;
  if (w < -40) w = -40;
  wordW[lastWordIdx] = (int8_t)w;
  int8_t x[4];
  wordInputs(x);
  for (uint8_t k = 0; k < 4; k++) {
    int32_t v = (int32_t)wordCtx[lastWordIdx][k] + (int32_t)reward * x[k] / 24;
    if (v > 60) v = 60;
    if (v < -60) v = -60;
    wordCtx[lastWordIdx][k] = (int8_t)v;
  }
  wordDecFresh = false;
  wordsDirty = true;
}

void wordsSave() {
#if USE_EEPROM
  if (!wordsDirty) return;
  eePend |= 2;
#endif
  wordsDirty = false;
}

/* v2.67: один шаг записи EEPROM (см. eePend): не больше EE_STEP реальных
 * записей и не дольше ~2 мс проверок за проход loop(). */
void eePumpTick() {
#if USE_EEPROM
  if (!eeWhat) {
    if (eePend & 1) { eeWhat = 1; eePend &= ~1; eeCur = 0; }
    else if (eePend & 2) { eeWhat = 2; eePend &= ~2; eeCur = 0; }
    else return;
  }
  uint8_t budget = EE_STEP;
  uint32_t t0 = micros();
  while (budget && (micros() - t0) < 2000UL) {
    int addr; uint8_t v;
    if (eeWhat == 1) {
      const uint16_t n = NET_OUT * NET_IN;
      if (eeCur < n) { addr = NET_WADDR + eeCur; v = ((const uint8_t *)netW)[eeCur]; }
      else if (eeCur == n) { addr = NET_MAGIC_ADDR; v = NET_MAGIC; }
      else { eeWhat = 0; return; }
    } else {
      const uint16_t n1 = WD_N, n2 = WD_N * 5;
      if (eeCur < n1) { addr = WORD_WADDR + eeCur; v = ((const uint8_t *)wordW)[eeCur]; }
      else if (eeCur < n2) { addr = WORD_WADDR + eeCur; v = ((const uint8_t *)wordCtx)[eeCur - n1]; }
      else if (eeCur == n2) { addr = WORD_MAGIC_ADDR; v = WORD_MAGIC; }
      else { eeWhat = 0; return; }
    }
    if (EEPROM.read(addr) != v) { EEPROM.write(addr, v); budget--; }
    eeCur++;
  }
#endif
}

bool wordsLoad() {
#if USE_EEPROM
  if (EEPROM.read(WORD_MAGIC_ADDR) != WORD_MAGIC) return false;
  uint8_t *p = (uint8_t *)wordW;
  for (uint16_t k = 0; k < WD_N; k++) p[k] = EEPROM.read(WORD_WADDR + k);
  p = (uint8_t *)wordCtx;
  for (uint16_t k = 0; k < WD_N * 4; k++)
    p[k] = EEPROM.read(WORD_WADDR + WD_N + k);
  return true;
#else
  return false;
#endif
}

/* Подкрепление от учителя: reward = +1/-1 на решения фразы */
void netTeach(int8_t reward) {
  LetterDec *buf = decisions; uint8_t n = decCount;
  if (lastDecFresh && lastDecCount) { buf = lastDec; n = lastDecCount; }
  if (!n) return;
  for (uint8_t d = 0; d < n; d++) {
    uint8_t ch = buf[d].ch; if (ch >= NET_OUT) continue;
    for (uint8_t i = 0; i < NET_IN; i++) {
      int32_t w = (int32_t)netW[ch][i] + (int32_t)reward * buf[d].x[i] / 24 * learningScale;
      if (w > 90) w = 90;
      if (w < -60) w = -60;
      netW[ch][i] = (int8_t)w;
    }
  }
  if (buf == lastDec) lastDecFresh = false;  // оценку получили — память свободна
  netDirty = true;
  netSave();
  wordTeach(reward);                  // v2.26: и выбор слова — тоже
  teachCount++;
  HUB_OUT.print("[NET] учитель: ");
  HUB_OUT.print(reward > 0 ? "+1 награда" : "-1 наказание");
  HUB_OUT.print(" (решений: "); HUB_OUT.print((unsigned)n); HUB_OUT.println(")");
}

/* ---------------- ТОЧЕЧНОЕ ОБУЧЕНИЕ (v2.6): кредит за букву --------------
 * Проблема netTeach: ОДНА оценка ±1 размазывается по ВСЕМ буквам фразы —
 * хорошие буквы наказываются вместе с плохими. Поэтому «оценки не работают».
 * v2.6 добавляет два точных метода (мозг вызывает их по мосту):
 *   teach_last(+1/-1)  — мгновенное подкрепление ПОСЛЕДНЕГО решения
 *                        (диктант: каждая буква сравнивается с целью);
 *   teach_shape("++-·+") — своя награда КАЖДОМУ решению запечатанной фразы
 *                        ('+' = +1, '-' = -1, прочее = пропуск);
 * teach_score(±1) остаётся как «глобальное мнение учителя».                   */
void netTeachOne(int8_t *x, uint8_t ch, int8_t reward) {
  if (ch >= NET_OUT) return;
  for (uint8_t i = 0; i < NET_IN; i++) {
    int32_t w = (int32_t)netW[ch][i] + (int32_t)reward * x[i] / 24 * learningScale;
    if (w > 90) w = 90;
    if (w < -60) w = -60;
    netW[ch][i] = (int8_t)w;
  }
  netDirty = true;
}

void rpcTeachLast(int reward) {
  if (!decCount) return;
  netTeachOne(decisions[decCount - 1].x, decisions[decCount - 1].ch,
              reward >= 0 ? 1 : -1);
  teachCount++;
  netSave();
}

void rpcTeachShape(String mask) {
  LetterDec *buf = decisions; uint8_t n = decCount;
  if (lastDecFresh && lastDecCount) { buf = lastDec; n = lastDecCount; }
  if (!n) return;
  uint8_t m = (mask.length() < (unsigned)n) ? (uint8_t)mask.length() : n;
  uint8_t hits = 0, pl = 0, mn = 0;
  for (uint8_t d = 0; d < m; d++) {
    char c = mask[d];
    if (c == '+') { netTeachOne(buf[d].x, buf[d].ch, 1); hits++; pl++; }
    else if (c == '-') { netTeachOne(buf[d].x, buf[d].ch, -1); hits++; mn++; }
    /* прочие символы — решение не трогаем */
  }
  /* v2.26: маска учителя подкрепляет и выбор слова (знак по большинству) */
  if (pl > mn) wordTeach(1);
  else if (mn > pl) wordTeach(-1);
  teachCount++;
  netSave();
  HUB_OUT.print("[NET] маска учителя: "); HUB_OUT.print(mask);
  HUB_OUT.print(" (изменений: "); HUB_OUT.print((unsigned)hits);
  HUB_OUT.print("/"); HUB_OUT.print((unsigned)n); HUB_OUT.println(")");
}

/* --------------------- СБОРКА СЛОВ И ФРАЗ (v2.3) ------------------------- */
void appendGenC(uint8_t num, const char *tok) {
  char item[14];
  snprintf(item, sizeof(item), "G%u:%s|", num, tok);
  uint16_t used = (uint16_t)strlen(val_c);
  if (used + strlen(item) >= VAL_C_SIZE - 1) {
    uint16_t cut = strlen(item);
    memmove(val_c, val_c + cut, used - cut + 1);
    used = (uint16_t)strlen(val_c);
  }
  strlcpy(val_c + used, item, VAL_C_SIZE - used);
}

void genSentAppend(const char *tok) {
  uint8_t bl = (uint8_t)strlen(tok);
  if (genSentLenB + bl >= sizeof(genSent) - 1) return;
  memcpy(genSent + genSentLenB, tok, bl);
  genSentLenB += bl; genSent[genSentLenB] = 0;
  genSentChars++;
}

/* v2.38: прижать знак к слову — убрать ХВОСТОВОЙ пробел фразы (после
 * сказанного слова фраза всегда кончается пробелом; знак должен дать
 * «СЛОВО,» и «СЛОВО.», а не «СЛОВО ,» / «СЛОВО .»). */
void genSentTrimSpace() {
  if (genSentLenB && genSent[genSentLenB - 1] == ' ') {
    genSent[--genSentLenB] = 0;
    if (genSentChars) genSentChars--;
  }
}

void decSeal() {   // фраза завершена: её решения ждут оценки учителя
  memcpy(lastDec, decisions, sizeof(LetterDec) * decCount);
  lastDecCount = decCount;
  lastDecFresh = true;
}

/* Слова уходят платам-нейронам как стимул: "STIM;<слово>" (код нейронов
 * НЕ менялся: стимул хешируется в входы перцептронов 3 секунды) */
void broadcastStimWord(const char *w) {
  char stim[36];
  snprintf(stim, sizeof(stim), "STIM;%.28s", w);
  utf8Fix(stim);   /* v2.24: %.28s резал по байтам — нейрону не сеем битую
                    * букву, иначе он возвращает её в словах вечно */
#if LINK_SW_WIRE
  for (uint8_t i = 0; i < NEURONS; i++) {
    NeuroBus.beginTransmission((uint8_t)(I2C_BASE_ADDR + i));
    NeuroBus.write((const uint8_t *)stim, (uint8_t)min((size_t)31, strlen(stim)));
    NeuroBus.endTransmission();
  }
#else
  NeuroSer.print(stim); NeuroSer.print('\n');
#endif
}

/* Слово готово: в фразе, в мелодию D8, нейронам стимулом */
/* v2.85: отсев «ахинеи» буквенной сети. Настоящее русское слово почти
 * всегда содержит гласную; три+ согласных подряд и повтор одной буквы
 * — признак лепета («ИЧИИЕИФИИЪ»). Если слово не из словаря и выглядит
 * как лепет — подменяем его случайным словом из WDICT, чтобы нейроны
 * помогали собирать связный текст, а не шум. */
bool wordLooksReal(const char *w) {
  if (!w || !w[0]) return false;
  uint8_t vowels = 0, consRun = 0, maxRun = 0, same = 0, last = 255, n = 0;
  for (uint8_t p = 0; w[p] && w[p + 1] && n < WORD_MAX; p += 2) {
    uint8_t num = letterNumOf(w + p);
    if (!num) return false;
    n++;
    uint8_t li = num - 1;
    if (RU_VOW[li]) { vowels++; consRun = 0; }
    else { consRun++; if (consRun > maxRun) maxRun = consRun; }
    if (li == last) same++; else same = 1;
    if (same >= 3) return false;                 // «ИИИ», «ААА»
    last = li;
  }
  if (n < 2) return true;                        // «Я», «ТЫ» и т.п.
  if (!vowels) return false;                     // одни согласные
  if (maxRun >= 4) return false;                 // «ЧЧЧЧ», «ШШШШ»
  return true;
}

void wordCommit(char tail) {
  if (!genWordLen) return;
  /* v2.85: буквенный лепет, не похожий на слово, не отдаём нейронам */
  if (dictCur == 255 && !wordLooksReal(genWord)) {
    uint8_t wi = (uint8_t)(lcgNext() % WD_N);
    strlcpy(genWord, WDICT[wi], sizeof(genWord));
    genWordLen = (uint8_t)strlen(genWord);
    HUB_OUT.print("[GEN] лепет заменён словарным: ");
    HUB_OUT.println(genWord);
  }
  if (tail) { char t[2] = {tail, 0}; genSentAppend(t); }
  wordsMade++;
  voiceWord(genWord);              // произношение слова динамиком (ноты)
  broadcastStimWord(genWord);      // слово — стимул для 12 плат-нейронов
  txtBump(14);                     // своё слово — текст-канал жив
  /* v2.22: на D6 идёт БУФЕР СЛОВА (его байты + хвост), а не номер буквы;
   * если играет фраза мозга (d6seq) — своё слово не подмешиваем.       */
  if (!d6Len) {
    char wb[WORD_MAX * 2 + 4];
    snprintf(wb, sizeof(wb), "%s%c", genWord, tail ? tail : ' ');
    d6PutText(wb);
  }
#if USE_RB
  Bridge.notify("on_word", String(genWord));   /* слово готово */
#endif
  genWordLen = 0; genWord[0] = 0;
}

/* Фраза завершена точкой: в итоговый буфер (SAY=), решения — учителю */
void sentenceDone() {
  if (genSentLenB) {
    uint8_t cut = (uint8_t)(SAY_MAX * 2);
    if (cut >= sizeof(sayBuf)) cut = sizeof(sayBuf) - 1;
    if (genSentLenB < cut) cut = genSentLenB;
    if (cut && (((uint8_t)genSent[cut - 1] == 0xD0) ||
                ((uint8_t)genSent[cut - 1] == 0xD1))) cut--;   // не рвать UTF-8
    memcpy(sayBuf, genSent, cut); sayBuf[cut] = 0;
    sentMade++;
    decSeal();
    HUB_OUT.print("[SAY] \""); HUB_OUT.print(sayBuf); HUB_OUT.println("\"");
  }
#if USE_RB
  if (sayBuf[0]) Bridge.notify("on_say", String(sayBuf));  /* фраза в буфере */
#endif
  genSentLenB = 0; genSent[0] = 0; genSentChars = 0;
  decCount = 0; afterPunct = false;
}

/* Частотный тег буквы: номер буквы 1..33 кладётся В ПОЛОСУ шины D4->A0 —
 * платы-нейроны слышат его своей пластикой (код нейронов не меняется).
 * Резервный цифровой канал "GEN;<тег>" несёт то же число.                 */
void letterPulse(uint8_t num) {
  uint16_t span = (cfgMaxHz > cfgMinHz + 40) ? (cfgMaxHz - cfgMinHz - 20) : 100;
  pulseHz = cfgMinHz + 10 + (uint16_t)((uint32_t)num * span / 33);
  if (pulseHz > cfgMaxHz) pulseHz = cfgMaxHz;
  pulseUntil = millis() + GEN_PULSE_MS;
  char g[16];
  snprintf(g, sizeof(g), "GEN;%u", pulseHz);
#if LINK_SW_WIRE
  for (uint8_t i = 0; i < NEURONS; i++) {
    NeuroBus.beginTransmission((uint8_t)(I2C_BASE_ADDR + i));
    NeuroBus.write((const uint8_t *)g, (uint8_t)strlen(g));
    NeuroBus.endTransmission();
  }
#else
  NeuroSer.print(g); NeuroSer.print('\n');
#endif
}

/* ШАГ ГЕНЕРАТОРА: нейросеть выбирает класс, механика собирает слова */
/* v2.26: ОДИН ШАГ СЛОВАРНОГО СЛОВА: буква за шагом — через ОБЫЧНЫЙ
 * конвейер (решения учителю, частотный тег буквы нейронам, val_c, D6,
 * мелодия D8). Слово взято из WDICT — лепета в готовых словах нет. */
void dictLetterTick() {
  const char *w = (dictSrc == 1) ? wordCur : WDICT[dictCur];   // v2.27
  uint8_t pair = (uint8_t)(dictPos * 2);
  int8_t x[NET_IN];
  netInputs(x);
  if (!w[pair] || genWordLen + 2 > sizeof(genWord) - 1) {
    /* слово кончилось — пробел, слово «сказано» */
    lastClass = CL_SPACE;
    curLetterNum = 0;
    strlcpy(curChr, "_", sizeof(curChr));
    wordCommit(' ');
    dictCur = 255; dictPos = 0; dictSrc = 0;   // v2.27
    lettersMade++;
    /* после слова — иногда точка: фразы естественной длины (2-6 слов) */
    if ((genSentChars >= SENT_MIN && (lcgNext() % 100) < 25) ||
        genSentChars >= SENT_MAX) {
      genSentTrimSpace();                    // v2.38: «СЛОВО.», не «СЛОВО .»
      genSentAppend(".");
      lastClass = CL_DOT;
      curLetterNum = 0;
      strlcpy(curChr, ".", sizeof(curChr));
      sentenceDone();
    }
    return;
  }
  uint8_t num = letterNumOf(w + pair);
  if (!num) { dictCur = 255; dictPos = 0; dictSrc = 0; return; }   // страховка
  dictPos++;
  lastClass = (uint8_t)(num - 1);
  curLetterNum = num;
  strlcpy(curChr, RU33[num - 1], sizeof(curChr));
  if ((size_t)genWordLen + 2 < sizeof(genWord)) {
    genWord[genWordLen++] = RU33[num - 1][0];
    genWord[genWordLen++] = RU33[num - 1][1];
    genWord[genWordLen] = 0;
  }
  genSentAppend(RU33[num - 1]);
  afterPunct = false;
  appendGenC(num, RU33[num - 1]);            // генератор живёт в val_c
  letterPulse(num);                          // номер буквы — в частоту шины
  /* решение для учителя — как у буквенной сети (кольцо DEC_MAX) */
  if (decCount < DEC_MAX) {
    memcpy(decisions[decCount].x, x, NET_IN);
    decisions[decCount].ch = (uint8_t)(num - 1);
    decCount++;
  } else {
    memmove(decisions, decisions + 1, sizeof(LetterDec) * (DEC_MAX - 1));
    memcpy(decisions[DEC_MAX - 1].x, x, NET_IN);
    decisions[DEC_MAX - 1].ch = (uint8_t)(num - 1);
  }
  lettersMade++;
}

/* v2.38: ЗНАК ОТ МОЗГА ИЗ ОЧЕРЕДИ СЛОВ. Знаки (",", ".", "!", "?") —
 * ЗАПИСИ СЛОВАРЯ (ru_top.json): мозг выбирает их сэмплером и присылает
 * word_push, как слова. Знак попадает во фразу той же механикой, что
 * знаки буквенной сети: запятая — между словами (", "), точка/!/ ? —
 * завершают фразу (SAY/D6-буфер уже наполнили слова; знак виден в
 * [SAY] и on_say, решение on_letter уходит в мост). СЕТЬ БУКВ НЕ
 * ТРОНУТА: веса 10x36, 36 выходов и решения учителю — как были; знак
 * сеть НЕ выбирала, поэтому в кольцо решений он не попадает.
 * Знак приходит ТОЛЬКО при пустом слове (очередь разбирается при
 * genWordLen == 0), поэтому wordCommit для знака не нужен. */
void boardMarkTick(char m) {
  if (m != ',' && m != '.' && m != '!' && m != '?') return;
  char s[2] = {m, 0};
  curLetterNum = 0;
  strlcpy(curChr, s, sizeof(curChr));
  lettersMade++;
  if (m == ',') {                            /* --- ЗАПЯТАЯ --- */
    if (genSentChars <= 0) return;           // запятая не бывает первой
    if (genSentChars >= SENT_MAX - 3) {      // не успевает — как у сети
      m = '.';
      s[0] = '.';                            // знак сменился — строка тоже
      strlcpy(curChr, s, sizeof(curChr));
    } else {
      genSentTrimSpace();                    // «СЛОВО ,» недопустимо
      genSentAppend(",");
      genSentAppend(" ");                    // пробел после запятой — сразу
      lastClass = CL_COMMA;
      /* afterPunct НЕ ставим: пробел уже вставлен, а если сеть следующим
       * шагом выберет свой пробел (после запятой она к нему расположена,
       * netW[CL_SPACE][9]), флаг дал бы ДВОЙНОЙ пробел во фразе. */
      Bridge.notify("on_letter", (int)0, String(curChr));
      return;
    }
  }
  /* --- ТОЧКА / «!» / «?» — конец фразы (как CL_DOT) --- */
  if (genSentChars < SENT_MIN) return;       // фраза коротка — знак мимо
  genSentTrimSpace();                        // знак прижат к слову
  genSentAppend(s);
  sentenceDone();
  lastClass = CL_DOT;                        // ! и ? ведут себя как точка
  Bridge.notify("on_letter", (int)0, String(curChr));
}

void letterTick() {
  if (millis() - tLetter < LETTER_TICK_MS) return;
  tLetter = millis();
  if (netDirty && millis() - netSaveAt > 30000) { netSaveAt = millis(); netSave(); }
  if (wordsDirty && millis() - wordsSaveAt > 30000) { wordsSaveAt = millis(); wordsSave(); }

  /* v2.27: словарное слово в процессе (WDICT или wordCur от мозга) —
   * идём по буквам через конвейер */
  if (dictCur != 255) { dictLetterTick(); return; }

  /* v2.86: ПРИОРИТЕТ — слово из большого словаря (ru_top.json, 30 000
   * слов, присылает Python word_pump). Локальные 64 слова и буквенный
   * лепет — только если очередь пуста уже долго (мозг не успевает). */
  if (genWordLen == 0 && lastClass >= CL_SPACE) {
    if (wordQCnt > 0) {
      strlcpy(wordPush, wordQ[wordQTail], sizeof(wordPush));
      wordQTail = (uint8_t)((wordQTail + 1) % WQ_N);
      wordQCnt--;
      if (wordPush[0] && !wordPush[1] && strchr(",.!?", wordPush[0])) {
        char m = wordPush[0];
        wordPush[0] = 0;
        boardMarkTick(m);
        return;
      }
      int8_t wi = wdictFind(wordPush);
      if (wi >= 0) {
        dictCur = (uint8_t)wi;
        dictSrc = 0;
        lastWordIdx = (uint8_t)wi;
        wordDecFresh = true;
      } else {
        strlcpy(wordCur, wordPush, sizeof(wordCur));
        dictSrc = 1;
        dictCur = 254;               // 254 = слово из wordCur (большой словарь)
        lastWordIdx = 255;
        wordDecFresh = false;
      }
      wordPush[0] = 0;
      dictPos = 0;
      wordsPicked++;
      return;
    }
    /* очередь пуста: ждём слово из 30 000. Локальный словарь — только
       если пусто уже > 1.5 с (мозг не успевает прислать). */
    static uint32_t tQEmpty = 0;
    if (!tQEmpty) tQEmpty = millis();
    if (millis() - tQEmpty < 1500) return;   // ждём word_pump
    tQEmpty = 0;
    if ((int)(lcgNext() % 100) < 80) {       // даже тогда — чаще словарь
      int8_t wx[4];
      wordInputs(wx);
      dictCur = wordPick(wx);
      dictPos = 0;
      lastWordIdx = dictCur;
      wordDecFresh = true;
      wordsPicked++;
      return;
    }
  }

  int8_t x[NET_IN];
  netInputs(x);
  uint8_t ch = netPick(x);

  /* --- механика сборки: отклонённый выбор заменяем допустимым --- */
  if (ch < 33) {
    if (genWordLen >= WORD_MAX * 2) ch = CL_SPACE;      // слово полное
  } else if (ch == CL_SPACE) {
    if (!genWordLen && !afterPunct) return;             // без двойных пробелов
  } else if (ch == CL_COMMA) {
    if (genSentChars >= SENT_MAX - 3) ch = CL_DOT;      // не успевает — точка
    else if (!genWordLen) return;                       // запятая только после слова
  } else if (ch == CL_DOT) {
    if (genSentChars < SENT_MIN) { if (genWordLen) ch = CL_SPACE; else return; }
  }

  /* запоминаем решение для учителя (кольцо: держим хвост фразы) */
  if (decCount < DEC_MAX) {
    memcpy(decisions[decCount].x, x, NET_IN);
    decisions[decCount].ch = ch; decCount++;
  } else {
    memmove(decisions, decisions + 1, sizeof(LetterDec) * (DEC_MAX - 1));
    memcpy(decisions[DEC_MAX - 1].x, x, NET_IN);
    decisions[DEC_MAX - 1].ch = ch;
  }
  lettersMade++;
  lastClass = ch;

  if (ch < 33) {                               /* --- БУКВА 1..33 --- */
    curLetterNum = ch + 1;
    strlcpy(curChr, RU33[ch], sizeof(curChr));
    if ((size_t)genWordLen + 2 < sizeof(genWord)) {
      genWord[genWordLen++] = RU33[ch][0];
      genWord[genWordLen++] = RU33[ch][1];
      genWord[genWordLen] = 0;
    }
    genSentAppend(RU33[ch]);
    afterPunct = false;
    appendGenC(curLetterNum, RU33[ch]);        // генератор живёт в val_c
    letterPulse(curLetterNum);                 // номер буквы — в частоту шины
    /* v2.19: буквы/слова больше НЕ печатаются в Serial (человек не должен
     * видеть «мысли» генератора): буква уходит в частотную шину, на D6
     * и в мост (on_letter) для обучения — но не на экран. */
  } else if (ch == CL_SPACE) {                 /* --- ПРОБЕЛ --- */
    curLetterNum = 0; strlcpy(curChr, "_", sizeof(curChr));
    if (afterPunct) { genSentAppend(" "); afterPunct = false; }
    else wordCommit(' ');
  } else if (ch == CL_COMMA) {                 /* --- ЗАПЯТАЯ --- */
    curLetterNum = 0; strlcpy(curChr, ",", sizeof(curChr));
    wordCommit(',');
    afterPunct = true;
  } else {                                     /* --- ТОЧКА --- */
    curLetterNum = 0; strlcpy(curChr, ".", sizeof(curChr));
    wordCommit('.');
    sentenceDone();
  }
  if (genSentChars >= SENT_MAX) { wordCommit('.'); sentenceDone(); }
  /* v2.22: номера букв на D6 больше НЕ выходят — пин несёт БУФЕР СЛОВ
   * (байты текста из wordCommit / d6seq), см. d6PutText и d6Tick. */
#if USE_RB
  Bridge.notify("on_letter", (int)curLetterNum, String(curChr));
#endif
}

/* v2.22: ПРОИГРЫВАНИЕ БУФЕРА СЛОВ НА D6: по БАЙТУ за D6_STEP_MS
 * (PWM = значение байта 0..255). По окончании пишем 0 — тишина до
 * следующего слова/фразы. */
void d6ImgTick() {
  if ((int32_t)(millis() - d6SlotMs) < 0) return;
  d6SlotMs = millis() + D6_STEP_MS;
  unsigned out = 0;
  uint8_t pxSlot = d6ImgNeg ? 3 : 1;
  if (d6Ph == 0) {                      // слот мысли
    if (d6Len && d6Pos < d6Len) {
      out = (unsigned)(uint8_t)d6Txt[d6Pos++];
      if (d6Pos >= d6Len) d6Len = 0;
    } else {
      d6Len = 0;
      if (d6FramePend && d6FrPos >= 4) { d6FramePend = false; d6FrPos = 0; }
      if (d6FrPos < 3) out = d6Frame[d6FrPos++];
      else if (d6FrPos == 3) d6FrPos = 4;
    }
  } else if (d6Ph == pxSlot) {          // слот точки кадра
    out = d6ImgTok(d6ImgIdx++);
  }
  analogWrite(NN_OUT_PIN, out);
  if (++d6Ph >= 4) {
    d6Ph = 0;
    if (d6ImgIdx >= D6_IMG_LEN) { d6ImgRun = false; analogWrite(NN_OUT_PIN, 0); }
  }
}

/* v2.93: раньше 8 analogRead на КАЖДЫЙ проход loop — АЦП Zephyr медленный,
 * и UART камеры (460800 бод, маленький приёмный буфер) за это время
 * переполнялся: кадры приходили битыми и не доходили до облака. Теперь одна
 * выборка раз в 4 мс, размах считается по окну из 8 выборок (~32 мс). */
static uint16_t capMn = 1023, capMx = 0;
static uint8_t  capN = 0;
static uint32_t capNextMs = 0;
void sampleCapNoise() {
  uint32_t now = millis();
  if ((int32_t)(now - capNextMs) < 0) return;
  capNextMs = now + 4;
  uint16_t v = analogRead(CAP_NOISE_PIN);
  if (v < capMn) capMn = v;
  if (v > capMx) capMx = v;
  if (++capN < 8) return;
  uint16_t span = capMx - capMn;
  capNoise = (uint8_t)min(255U, span / 2);   // грубая нормализация
  capMn = 1023; capMx = 0; capN = 0;
}

void noiseAsStim() {
  if (capNoise < 30) return;                 // порог
  uint32_t now = millis();
  if ((int32_t)(now - noiseStimMs) < 400) return;  // не чаще 2.5 Гц
  noiseStimMs = now;
  /* Стимул нейронам: чем сильнее шум — тем «ярче» слово-стимул */
  char stim[20];
  if (capNoise > 120) snprintf(stim, sizeof(stim), "STIM;NOISEHI");
  else if (capNoise > 60) snprintf(stim, sizeof(stim), "STIM;NOISE");
  else snprintf(stim, sizeof(stim), "STIM;NOISELO");
  camUartTick();                             // v2.93: UART камеры не ждёт I2C
  broadcastStimWord(stim + 5);               // без префикса, функция сама добавляет
  camUartTick();
#if USE_RB
  /* v2.93: три RPC в Linux — не чаще раза в секунду (было 2.5 Гц) */
  static uint32_t noiseNotifyMs = 0;
  if ((int32_t)(now - noiseNotifyMs) >= 1000) {
    noiseNotifyMs = now;
    Bridge.notify("cap_noise", (int)capNoise);
    camUartTick();
    Bridge.notify("d6_act", (int)d6Activity);
    camUartTick();
    Bridge.notify("learn_scale", (int)learningScale);
  }
#endif
  /* Временный подъём частоты генератора — нейроны сильнее пластичны */
  if (genHz < GEN_MAX_HZ - 100) genHz += 40;
}

void updateLearningScale() {
  /* d6Activity растёт от particleTick и d6 PWM, спадает сам */
  if (d6Activity > 0) d6Activity--;
  uint16_t eff = (uint16_t)capNoise + d6Activity;
  if (eff > 180) learningScale = 4;
  else if (eff > 100) learningScale = 3;
  else if (eff > 40) learningScale = 2;
  else learningScale = 1;
}

void particleTick() {
  if (!(partGrav || partMuon || partPhot)) return;
  uint32_t now = millis();
  if ((int32_t)(now - partNextMs) < 0) return;
  partNextMs = now + 80;   // ~12.5 Гц кванты
  uint8_t level = 0;
  if (partPhot && (partPhase % 5 == 0)) level = 220;          // короткая вспышка фотона
  else if (partMuon && (partPhase % 3 == 0)) level = 140;     // пакет мюона
  else if (partGrav) level = 40 + (partPhase % 20);           // низкий фон гравитона
  if (level) { analogWrite(NN_OUT_PIN, level); d6Activity = min(255, d6Activity + 8); }
  partPhase++;
}

void d6Tick() {
  if (d6PureTick(d6Len > 0 || d6FramePend || d6FrPos < 4)) return;   // v2.49
  if (d6ImgRdy && !d6ImgRun) {          // принятый кадр -> развёртка
    memcpy(d6Img, d6ImgIn, D6_IMG_N);
    d6ImgNeg = d6ImgInNeg; d6ImgRdy = false;
    d6ImgRun = true; d6ImgIdx = 0; d6Ph = 0; d6SlotMs = 0;
  }
  if (d6ImgRun) { d6ImgTick(); return; }
  if (!d6Len) {
    if (d6FramePend && d6FrPos >= 4) {          // текст кончился — кадр
      d6FramePend = false;
      d6FrPos = 0; d6NextMs = 0;
    }
    if (d6FrPos < 4) {
      if ((int32_t)(millis() - d6NextMs) < 0) return;
      analogWrite(NN_OUT_PIN, d6FrPos < 3 ? (unsigned)d6Frame[d6FrPos] : 0u);
      d6FrPos++;
      d6NextMs = millis() + D6_STEP_MS;
    }
    return;
  }
  if (d6Pos >= d6Len) {
    analogWrite(NN_OUT_PIN, 0);
    d6Len = 0;
    return;
  }
  if ((int32_t)(millis() - d6NextMs) < 0) return;
  analogWrite(NN_OUT_PIN, (unsigned)(uint8_t)d6Txt[d6Pos++]);
  d6NextMs = millis() + D6_STEP_MS;
}

/* ----------------------------- ГЕНЕРАТОР ЧАСТОТЫ ------------------------- */
/* Меандр на GEN_PIN с догоняющим планировщиком: даже после долгой блокировки
 * (опрос нейронов, мост) средняя частота на шине остаётся равной genHz —
 * нейроны считают фронты за окно и получают точное значение.                */
void freqTick() {
  if (genHz < 20 || d4fRun) return;     // v2.50: идёт кадр на D4
  uint32_t perUs = 1000000UL / genHz;
  uint32_t highUs = perUs / 2;                          // v2.48: полярность D4
  if (d4Pol > 0) highUs = perUs / 3;
  else if (d4Pol < 0) highUs = perUs * 2 / 3;
  uint32_t lowUs = perUs - highUs;
  if ((int32_t)(micros() - nextEdgeUs) < 0) return;
  uint8_t guard = 0;
  do {
    genOut = !genOut;
    digitalWrite(GEN_PIN, genOut ? HIGH : LOW);
    nextEdgeUs += genOut ? highUs : lowUs;
  } while (++guard < 200 && (int32_t)(micros() - nextEdgeUs) >= 0);
  if (guard >= 200) nextEdgeUs = micros();   // после длинного простоя — ресинхронизация
}

/* ----------------------------- ОПРОС НЕЙРОНОВ ---------------------------- */
void notePacket(uint8_t id, uint32_t spikes, const char *word) {
  if (id >= NEURONS) return;
  ns[id].spikes = spikes;
  /* v2.26: alive ставит ВЫЗЫВАЮЩИЙ (по факту ответа АДРЕСА) — данные же
   * пишутся в слот того номера, который нейрон сообщил сам (real). */
  strlcpy(ns[id].word, word, TEXT_MAX + 1);
  sanitize(ns[id].word);
}

/* Добавляем реплику нейрона в val_c: "N5:1042:сигнал|" */
void appendValC(uint8_t id, uint32_t spikes, const char *word) {
  char item[TEXT_MAX + 24];
  snprintf(item, sizeof(item), "N%u:%lu:%s|", id, (unsigned long)spikes, word);
  uint16_t used = (uint16_t)strlen(val_c);
  if (used + strlen(item) >= VAL_C_SIZE - 1) {   // вытесняем начало
    uint16_t cut = strlen(item);
    memmove(val_c, val_c + cut, used - cut + 1);
    used = (uint16_t)strlen(val_c);
  }
  strlcpy(val_c + used, item, VAL_C_SIZE - used);
}

/* Частота генератора -> платам-нейронам (резервный цифровой канал).
 * Основной канал — сама частота на проводе D4->A0: нейрон считает фронты.
 * "GEN;<hz>" остаётся для калибровки и на случай тихой шины.               */
void broadcastGen() {
  char g[16];
  snprintf(g, sizeof(g), "GEN;%u", genHz);
#if LINK_SW_WIRE
  for (uint8_t i = 0; i < NEURONS; i++) {
    NeuroBus.beginTransmission((uint8_t)(I2C_BASE_ADDR + i));
    NeuroBus.write((const uint8_t *)g, (uint8_t)strlen(g));
    NeuroBus.endTransmission();
  }
#else
  NeuroSer.print(g); NeuroSer.print('\n');   // услышит текущий канал мультиплексора
#endif
}

/* Кэш/буфер облака -> платам-нейронам: "BUF;<фрагмент>" (v1.3). Нейроны
 * воспринимают сводку облака как свежий внешний сигнал (вспышка LED).
 * ВАЖНО: cloud_buf уже санитизирован при приёме — sanitize() здесь НЕ
 * применяется, иначе он превратит разделитель ";" в ",".                */
void broadcastBuf() {
  txtBump(10);                         // облако «сказало» слово — текст-канал жив
  char b[30];
  snprintf(b, sizeof(b), "BUF;%.24s", cloud_buf);
  utf8Fix(b);                          /* v2.24: обрезка по границе буквы */
#if LINK_SW_WIRE
  for (uint8_t i = 0; i < NEURONS; i++) {
    NeuroBus.beginTransmission((uint8_t)(I2C_BASE_ADDR + i));
    NeuroBus.write((const uint8_t *)b, (uint8_t)strlen(b));
    NeuroBus.endTransmission();
  }
#else
  NeuroSer.print(b); NeuroSer.print('\n');
#endif
}

/* Новая функция из реестра облака -> платам-нейронам: "SKIL;<имя>" (v1.4).
 * Нейрон отвечает двойной вспышкой LED и всплеском активации — сеть
 * «отмечает» появление новой функции мозга.                            */
void broadcastSkill() {
  txtBump(12);                         // новая функция — заметное текст-событие
  char b[30];
  snprintf(b, sizeof(b), "SKIL;%.20s", skill_out);
  utf8Fix(b);                          /* v2.24: обрезка по границе буквы */
#if LINK_SW_WIRE
  for (uint8_t i = 0; i < NEURONS; i++) {
    NeuroBus.beginTransmission((uint8_t)(I2C_BASE_ADDR + i));
    NeuroBus.write((const uint8_t *)b, (uint8_t)strlen(b));
    NeuroBus.endTransmission();
  }
#else
  NeuroSer.print(b); NeuroSer.print('\n');
#endif
}

/* v2.24: счётчик МУСОРНЫХ ответов с шины нейронов (шум на длинных
 * проводах): растёт на каждом битом пакете, обнуляется хорошим.
 * Показывается в [NET] как «шум шины», всплеск чинит шину (pollNext). */
uint32_t busBad = 0;

int8_t idSeen[NEURONS];           /* v2.26: какой № сообщал слот (лог при смене) */

#if LINK_SW_WIRE
/* v2.23: живость нейрона — сбрасываем только после НЕСКОЛЬКИХ пустых
 * опросов подряд: одиночный сбой шины не гасит нейрон в карте NET и не
 * отправляет его в DEAD_SKIP-пропуск. */
#define MISS_DEAD      3
void pollNeuronWire(uint8_t idx) {
  NeuroBus.requestFrom((uint8_t)(I2C_BASE_ADDR + idx), (uint8_t)32);
  char buf[33]; uint8_t n = 0;
  while (NeuroBus.available() && n < 32) buf[n++] = (char)NeuroBus.read();
  buf[n] = 0;
  if (n == 0) {
    /* v2.23: РЕТРАЙ — одиночная помеха на длинных проводах не должна
     * объявлять нейрон мёртвым */
    NeuroBus.requestFrom((uint8_t)(I2C_BASE_ADDR + idx), (uint8_t)32);
    while (NeuroBus.available() && n < 32) buf[n++] = (char)NeuroBus.read();
    buf[n] = 0;
    if (n == 0) {
      if (ns[idx].miss < 255) ns[idx].miss++;
      if (ns[idx].miss >= MISS_DEAD) ns[idx].alive = false;
      return;
    }
  }
  ns[idx].miss = 0;
  /* v2.24: ЖЁСТКАЯ ПРОВЕРКА ПАКЕТА (формат N<id>;<спайки>;<слово>).
   * Раньше слово уходило в мозг и мост КАК ЕСТЬ: битые байты ломали
   * UTF-8, и Python терял события ('utf-8' codec can't decode ...).
   * Мусорный пакет теперь не попадает в нейросеть — только busBad++. */
  char *p1 = strchr(buf, ';');
  char *p2 = p1 ? strchr(p1 + 1, ';') : nullptr;
  if (buf[0] != 'N' || !p1 || !p2) { busBad++; return; }
  *p1 = 0; *p2 = 0;
  bool ok = (p1[1] != 0);
  uint32_t sp = 0;
  for (char *q = p1 + 1; *q; q++) {
    if (*q < '0' || *q > '9') { ok = false; break; }
    sp = sp * 10 + (uint32_t)(*q - '0');
  }
  if (!ok) { busBad++; return; }          // спайки не число — мусор
  char clean[TEXT_MAX + 1];
  strlcpy(clean, p2 + 1, sizeof(clean));  // <= TEXT_MAX байт: обрыв хвоста
  sanitize(clean);
  utf8Fix(clean);                         // v2.24: битая буква -> пробел
  busBad = 0;                             // хороший пакет — шум кончился
  /* v2.26: ЧЕСТНЫЕ АДРЕСА: верим номеру, который нейрон сообщает сам.
   * Раньше данные писались в слот ОПРАШИВАЕМОГО адреса — нейрон,
   * сбросившийся на другой адрес/номер («пишет 1 вместо 2»), терял
   * спайки и слова («их только два»). Код нейронов НЕ меняется. */
  uint8_t real = idx;
  if (p1 > buf + 1) {
    long rid = 0; bool okId = true;
    for (char *q = buf + 1; q < p1; q++) {
      if (*q < '0' || *q > '9') { okId = false; break; }
      rid = rid * 10 + (*q - '0');
    }
    if (okId && rid >= 0 && rid < NEURONS) real = (uint8_t)rid;
  }
  if (real != idx && idSeen[idx] != (int8_t)real) {
    idSeen[idx] = (int8_t)real;
    HUB_OUT.print("[NET] нейрон сообщает №");
    HUB_OUT.print((unsigned)real);
    HUB_OUT.print(" с адреса 0x");
    HUB_OUT.print(I2C_BASE_ADDR + idx, HEX);
    HUB_OUT.print(" (слот №");
    HUB_OUT.print((unsigned)idx);
    HUB_OUT.println(") — данные идут по его слову");
  }
  ns[idx].alive = true;                   // АДРЕС отвечает (карта NET)
  notePacket(real, sp, clean);            // спайки/слово — по слову нейрона
  appendValC(real, sp, clean);
}

/* v2.23: ВОССТАНОВЛЕНИЕ ЗАВИСШЕЙ ШИНЫ I2C. Классическая беда: после помехи
 * или сброса нейрона ведомый держит SDA прижатой к земле — мастер читает
 * «занято», и ВСЕ нейроны после этого молчат (вживую выглядит как
 * «работают только два»). Лечение по спецификации I2C: 9 тактов SCL при
 * отпущенной SDA, затем STOP. Зовётся при старте и из pollNext, когда
 * молчат ВСЕ нейроны (не чаще раза в минуту). Обычные пины D2/D3. */
void i2cBusRecover() {
  pinMode(BUS_SDA, INPUT_PULLUP);
  pinMode(BUS_SCL, OUTPUT);
  digitalWrite(BUS_SCL, HIGH);
  for (uint8_t i = 0; i < 9 && digitalRead(BUS_SDA) == LOW; i++) {
    digitalWrite(BUS_SCL, LOW);
    delayMicroseconds(20);
    digitalWrite(BUS_SCL, HIGH);
    delayMicroseconds(20);
  }
  digitalWrite(BUS_SCL, LOW);          // STOP: SCL=0 -> SDA=0 -> отпустить
  pinMode(BUS_SDA, OUTPUT);
  digitalWrite(BUS_SDA, LOW);
  delayMicroseconds(20);
  pinMode(BUS_SDA, INPUT_PULLUP);      // SDA отпущена — шина свободна
  digitalWrite(BUS_SCL, HIGH);
  delayMicroseconds(20);
  digitalWrite(BUS_SCL, LOW);
  NeuroBus.begin();                    // переинициализация SoftwareWire
}
#else
void setMux(uint8_t ch) {
  for (uint8_t b = 0; b < 4; b++)
    digitalWrite(MUX_PINS[b], (ch >> b) & 1 ? HIGH : LOW);
}
void pollNeuronSer(uint8_t idx) {
  setMux(idx);
  while (NeuroSer.available()) NeuroSer.read();  // чистим приёмник
  NeuroSer.print("POLL\n");
  /* v2.18: ожидание 30 -> 15 мс — живой нейрон отвечает за 1-5 мс,
   * а молчащий перестал тормозить loop вдвое дольше нужного */
  uint32_t t0 = millis(); char buf[40]; uint8_t n = 0;
  while (millis() - t0 < 15) {
    while (NeuroSer.available() && n < 39) {
      char c = (char)NeuroSer.read();
      if (c == '\n') { buf[n] = 0; goto got; }
      buf[n++] = c;
    }
  }
  buf[n] = 0; if (n == 0) { ns[idx].alive = false; return; }
got:
  /* v2.24: та же жёсткая проверка, что и в pollNeuronWire */
  char *p1 = strchr(buf, ';');
  char *p2 = p1 ? strchr(p1 + 1, ';') : nullptr;
  if (buf[0] != 'N' || !p1 || !p2) { busBad++; return; }
  *p1 = 0; *p2 = 0;
  bool ok = (p1[1] != 0);
  uint32_t sp = 0;
  for (char *q = p1 + 1; *q; q++) {
    if (*q < '0' || *q > '9') { ok = false; break; }
    sp = sp * 10 + (uint32_t)(*q - '0');
  }
  if (!ok) { busBad++; return; }
  char clean[TEXT_MAX + 1];
  strlcpy(clean, p2 + 1, sizeof(clean));
  sanitize(clean);
  utf8Fix(clean);                         // v2.24: мост не падает на UTF-8
  busBad = 0;
  /* v2.26: честные адреса — как в pollNeuronWire (верим слову нейрона) */
  uint8_t real = idx;
  if (p1 > buf + 1) {
    long rid = 0; bool okId = true;
    for (char *q = buf + 1; q < p1; q++) {
      if (*q < '0' || *q > '9') { okId = false; break; }
      rid = rid * 10 + (*q - '0');
    }
    if (okId && rid >= 0 && rid < NEURONS) real = (uint8_t)rid;
  }
  if (real != idx && idSeen[idx] != (int8_t)real) {
    idSeen[idx] = (int8_t)real;
    HUB_OUT.print("[NET] нейрон сообщает №");
    HUB_OUT.print((unsigned)real);
    HUB_OUT.print(" с адреса 0x");
    HUB_OUT.print(I2C_BASE_ADDR + idx, HEX);
    HUB_OUT.print(" (слот №");
    HUB_OUT.print((unsigned)idx);
    HUB_OUT.println(") — данные идут по его слову");
  }
  ns[idx].alive = true;                   // АДРЕС отвечает (карта NET)
  notePacket(real, sp, clean);
  appendValC(real, sp, clean);
}
#endif

/* v2.18: МЕРТВЫЕ НЕЙРОНЫ ОПРАШИВАЕМ РЕДКО. Пока скетч ждёт ответа молчащей
 * платы (а с SoftwareWire — тем более), loop стоит и мост голодает. Живые
 * опрашиваются каждый круг, молчащие — раз в DEAD_SKIP кругов. */
#define DEAD_SKIP      8

uint8_t  allMiss = 0;             // v2.23: сколько подряд опросов молчат ВСЕ
uint32_t lastRecover = 0;         // v2.23: когда последний раз чинили шину

void pollNext() {
  if (millis() - tPoll < POLL_MS) return;
  tPoll = millis();
  /* v2.18: пропуск молчащих — loop не блокируется на пустом адресе */
  for (uint8_t tries = 0; tries < NEURONS; tries++) {
    if (ns[pollIdx].alive || ((cycle + pollIdx) % DEAD_SKIP) == 0) break;
    pollIdx = (pollIdx + 1) % NEURONS;
    /* ФИКС «1/12»: круг завершается и тогда, когда переход через 0
     * случился при ПРОПУСКЕ молчащих. Раньше cycle++ был только после
     * опроса №11 — пока он молчал, cycle замирал, и молчащие слоты
     * (при старте — все) больше никогда не опрашивались: вечно
     * проверялись лишь адреса 0x10 и 0x18. */
    if (pollIdx == 0) cycle++;
  }
#if LINK_SW_WIRE
  pollNeuronWire(pollIdx);
#else
  pollNeuronSer(pollIdx);
#endif
  pollIdx = (pollIdx + 1) % NEURONS;
  if (pollIdx == 0) {          // завершён круг по всем 12 нейронам
    cycle++;
    if (strlen(val_c) == 0) strlcpy(val_c, "silence", VAL_C_SIZE);
  }
#if LINK_SW_WIRE
  /* v2.23: молчат ВСЕ нейроны подряд — шина зависла, чиним (не чаще
   * раза в минуту; после помехи нейроны возвращаются БЕЗ перезагрузки) */
  bool anyAlive = false;
  for (uint8_t i = 0; i < NEURONS; i++) if (ns[i].alive) anyAlive = true;
  if (!anyAlive) {
    if (allMiss < 255) allMiss++;
    if (allMiss >= 100 && millis() - lastRecover > 60000UL) {
      lastRecover = millis();
      allMiss = 0;
      HUB_OUT.println("[NET] вся шина молчит — восстановление I2C (9 тактов SCL)");
      i2cBusRecover();
    }
  } else {
    allMiss = 0;
  }
  /* v2.24: ШУМ, а не тишина — всплеск мусорных ответов тоже чинит шину.
   * Раньше при паре живых нейронов зависание шины на остальных никак
   * не лечилось (allMiss не рос). busBad >= 40 подряд (не сбрасываясь
   * хорошим пакетом) — явная помеха/зависание: 9 тактов SCL + STOP. */
  if (busBad >= 40 && millis() - lastRecover > 60000UL) {
    lastRecover = millis();
    HUB_OUT.print("[NET] мусорные ответы с шины (");
    HUB_OUT.print((unsigned long)busBad);
    HUB_OUT.println(") — восстановление I2C (9 тактов SCL)");
    i2cBusRecover();
    busBad = 0;
  }
#endif
}

/* ----------------------------- АНАЛИЗ val_c ------------------------------ */
/* Анализ + печать в total_val_c. Формат:
 * TS=..;SPK=..;ACT=..;TOP=..;TOK=..;HSH=..;CYC=..;GEN=..;CAM=..;MIC=..;
 * TXT=..;VB=..;CLD=..;SKL=..;MSG=...                                       */
void analyzeAndPrint() {
  if (millis() - tAnalyze < ANALYZE_MS) return;
  tAnalyze = millis();

  uint32_t spkSum = 0; uint8_t active = 0; int8_t top = -1; uint32_t topSpk = 0;
  uint16_t tokens = 0;
  /* v2.26: активность/топ/слова — по ДАННЫМ (кто реально прислал спайки,
   * пусть даже с «чужого» адреса); карта NET отдельно показывает адреса */
  for (uint8_t i = 0; i < NEURONS; i++) {
    if (ns[i].spikes > 0) {
      active++;
      if (strlen(ns[i].word) > 0) tokens++;
      if (ns[i].spikes > topSpk) { topSpk = ns[i].spikes; top = i; }
    }
    spkSum += ns[i].spikes;
  }

  char msg[240] = "";
  for (uint8_t i = 0; i < NEURONS && strlen(msg) < 220; i++) {
    if (ns[i].spikes > 0) {
      char it[TEXT_MAX + 20];
      snprintf(it, sizeof(it), "N%u:%lu:%s|", i, (unsigned long)ns[i].spikes, ns[i].word);
      strlcat(msg, it, sizeof(msg));
      ns[i].spikes = 0;                  // окно сброшено — статистика ушла в total_val_c
    }
  }
  if (!msg[0]) strlcpy(msg, "quiet", sizeof(msg));
  utf8Fix(msg);   /* v2.24: слова нейронов чищены при приёме — подстраховка */

  /* v2.11: КАРТА СВЯЗИ С НЕЙРОНАМИ — кто отвечал на опрос в этом цикле.
   * NET[i]='1' если нейрон №i вернул пакет (ns[i].alive), '0' если молчит.
   * Уходит в total_val_c (NET=), в строку Serial [GEN] и в Bridge.notify
   * on_net — проверка связи видна и в мониторе порта, и в интерфейсе. */
  char netMask[NEURONS + 1];
  for (uint8_t i = 0; i < NEURONS; i++) netMask[i] = ns[i].alive ? '1' : '0';
  netMask[NEURONS] = 0;

  /* ------- СИНТЕЗ ЧАСТОТЫ: камера + микрофон + текст + спайки ------------ */
  uint8_t camLvl = camScore();                       // 0..100: что видит камера
  uint8_t micLvl = micLevel;                         // 0..100: что слышит микрофон
  uint8_t spkLvl = (uint8_t)((uint32_t)(spkSum > 60 ? 60 : spkSum) * 100 / 60);
  txtLevel = (uint8_t)((uint32_t)txtLevel * 95 / 100);   // затухание текст-канала
  uint8_t txtTok = (uint8_t)((uint32_t)tokens * 8 > 100 ? 100 : tokens * 8);
  uint8_t txtLvl = txtLevel > txtTok ? txtLevel : txtTok; // что пишет сам / ему написали

  uint16_t fTarget = cfgMinHz
      + (uint16_t)((uint32_t)cfgCamSpan * camLvl / 100)
      + (uint16_t)((uint32_t)cfgMicSpan * micLvl / 100)
      + (uint16_t)((uint32_t)cfgTxtSpan * txtLvl / 100)
      + (uint16_t)((uint32_t)cfgSpkSpan * spkLvl / 100);
  if (fTarget > cfgMaxHz) fTarget = cfgMaxHz;
  if (fTarget < cfgMinHz) fTarget = cfgMinHz;
  /* v2.67: подтяжка к общему ритму платформы */
  if (syncK && syncHz && (millis() - syncTs) < SYNC_TTL_MS) {
    int32_t d = (int32_t)syncHz - (int32_t)fTarget;
    fTarget = (uint16_t)((int32_t)fTarget + d * (int32_t)syncK / 100);
    if (fTarget > cfgMaxHz) fTarget = cfgMaxHz;
    if (fTarget < cfgMinHz) fTarget = cfgMinHz;
  }
  spkLvlLast = spkLvl;                               // вход нейросети букв

  /* v2.3: ЧАСТОТНЫЙ ТЕГ БУКВЫ — пока активен, на шине точная частота-номер */
  if ((int32_t)(pulseUntil - millis()) > 0) {
    genHz = pulseHz;
  } else {
    int16_t dHz = (int16_t)fTarget - (int16_t)genHz;
    genHz = (uint16_t)((int16_t)genHz + dHz / 4);      // плавное дыхание частоты
    if (dHz >= GEN_DEADBAND || -dHz >= GEN_DEADBAND)
      broadcastGen();                                  // темп пластики нейронам (резерв)
  }

  /* ---- МОТИВАЦИЯ ГОВОРИТЬ (v1.9): мозг «хочет говорить» ---------------- */
  /* Если текст-канал или спайки высоки и давно не говорил — короткий
   * сигнал готовности. Динамик -> микрофон -> частота: петля самостимуляции,
   * ограниченная VOICE_IDLE_MS и анти-заводкой в voiceSay().              */
  if (!voxSteps && (millis() - lastPhraseMs > VOICE_IDLE_MS) &&
      (txtLvl >= VOICE_READY || spkLvl >= 80))
    voiceSay(genHz, 2);

  snprintf(total_val_c, TOTAL_SIZE,
           "TS=%lu;SPK=%lu;ACT=%u;TOP=%d;TOK=%u;HSH=%06lX;CYC=%lu;GEN=%u;CAM=%u;MIC=%u;TXT=%u;VOX=%u;TCH=%u;LTR=%u;CHR=%s;WRD=%.22s;SAY=%.48s;VB=%.90s;CLD=%.40s;SKL=%.12s;NET=%s;MSG=%s",
           (unsigned long)millis(), (unsigned long)spkSum, active, (int)top,
           tokens, (unsigned long)(fnv1a(val_c) & 0xFFFFFF),
           (unsigned long)cycle, (unsigned)genHz,
           (unsigned)camLvl, (unsigned)micLvl, (unsigned)txtLvl,
           (unsigned)voxCount, (unsigned)teachCount, (unsigned)curLetterNum,
           curChr, genWord, sayBuf, val_b, cloud_buf, skill_out, netMask, msg);
  utf8Fix(total_val_c);   /* v2.24: %.Ns-обрезки не рвут букву UTF-8 */

  /* v2.3: информация о частоте ВСЕГДА видна в Serial (и в GEN= total_val_c,
   * и в коротком ключе gen_hz моста — потеряться больше не может).
   * v2.19: буквы (LTR/CHR) и слова (WRD) из печати УБРАНЫ — человек не
   * видит «мысли» генератора; осталась частота и готовая фраза SAY. */
  HUB_OUT.print("[GEN] "); HUB_OUT.print((unsigned)genHz); HUB_OUT.print(" Hz");
  HUB_OUT.print(" | SAY=\""); HUB_OUT.print(sayBuf); HUB_OUT.print("\"");
  /* v2.11: карта связи — сразу видно в мониторе порта, кто не отвечает */
  HUB_OUT.print(" | NET="); HUB_OUT.print(netMask);
  HUB_OUT.print(" (");
  uint8_t netOk = 0; for (uint8_t i = 0; i < NEURONS; i++) if (ns[i].alive) netOk++;
  HUB_OUT.print((unsigned)netOk); HUB_OUT.print("/"); HUB_OUT.print((unsigned)NEURONS);
  HUB_OUT.print(" отвечают");
#if LINK_SW_WIRE
  if (busBad) {
    HUB_OUT.print(", шум шины: "); HUB_OUT.print((unsigned long)busBad);
  }
#endif
  HUB_OUT.println(")");
#if USE_RB
  /* v2.87: все строки в мост — только после utf8Fix, иначе
   * Bridge.read_loop падает на 0x93/0x91/0xa6 */
  utf8Fix(curChr);
  utf8Fix(genWord);
  utf8Fix(sayBuf);
  Bridge.notify("on_state", (int)genHz, (int)curLetterNum, String(curChr),
                String(genWord), String(sayBuf), (int)spkSum, (int)active,
                (int)top, (int)cycle);
  static char lastNet[NEURONS + 1];       /* v2.11: on_net — при изменении */
  if (strncmp(netMask, lastNet, sizeof(lastNet)) != 0) {
    strncpy(lastNet, netMask, sizeof(lastNet) - 1); lastNet[sizeof(lastNet) - 1] = 0;
    utf8Fix(lastNet);
    Bridge.notify("on_net", String(lastNet));
  }
  static char lastMsg[240];                 /* on_msg — только при изменении */
  if (strncmp(msg, lastMsg, sizeof(lastMsg)) != 0) {
    strncpy(lastMsg, msg, sizeof(lastMsg) - 1); lastMsg[sizeof(lastMsg) - 1] = 0;
    utf8Fix(lastMsg);
    Bridge.notify("on_msg", String(lastMsg));
  }
#endif
}

/* ----------------------------- СВЯЗЬ С LINUX-СТОРОНОЙ -------------------- */
void broadcastStim(const char *text) {
  txtBump(35);                         // мозг пишет сам / ему написали — текст жив
  voiceSay(genHz, 3);                  // МОТИВАЦИЯ ГОВОРИТЬ: мозг «собирается с мыслями»
  char clean[CHAT_OUT_SIZE];
  strlcpy(clean, text, CHAT_OUT_SIZE);
  sanitize(clean);                       // чистим ТОЛЬКО текст стимула
  char stim[CHAT_OUT_SIZE + 8];
  snprintf(stim, sizeof(stim), "STIM;%s", clean);   // иначе нейрон не узнает "STIM;"
  utf8Fix(stim);                       /* v2.24: в мост/нейронам — целый UTF-8 */
#if LINK_SW_WIRE
  for (uint8_t i = 0; i < NEURONS; i++) {
    NeuroBus.beginTransmission((uint8_t)(I2C_BASE_ADDR + i));
    NeuroBus.write((const uint8_t *)stim, (uint8_t)min((size_t)31, strlen(stim)));
    NeuroBus.endTransmission();
  }
#else
  NeuroSer.print(stim); NeuroSer.print('\n');
#endif
}

#if USE_RB
/* ================== RPC v2.4: ПРИЁМ КОМАНД ОТ PYTHON-СТОРОНЫ ============ */
/* Обработчики регистрируются через provide_safe — исполняются в потоке
 * loop() (без гонок с буферами). Внутри обработчиков Bridge.call
 * запрещён (дедлок MCU-CPU), поэтому они только меняют состояние и
 * запускают эффекты (стимулы/мелодии/настройки).                        */
void rpcChatStim(String text) {
  strlcpy(chat_out, text.c_str(), CHAT_OUT_SIZE);
  sanitize(chat_out);
  broadcastStim(chat_out);        /* текст пользователя -> STIM нейронам */
}
void rpcValB(String summary) {
  strlcpy(val_b, summary.c_str(), VAL_B_SIZE);
  sanitize(val_b);                /* сводка YOLO -> шина/total_val_c    */
}
void rpcCloudBuf(String s) {
  if (s.length() && strcmp(s.c_str(), cloud_buf) != 0) {
    strlcpy(cloud_buf, s.c_str(), CLOUD_BUF_SIZE);
    sanitize(cloud_buf);
    broadcastBuf();               /* сводка облака -> нейронам          */
  }
}
void rpcSkillOut(String s) {
  if (s.length() && strcmp(s.c_str(), skill_out) != 0) {
    strlcpy(skill_out, s.c_str(), SKILL_OUT_SIZE);
    sanitize(skill_out);
    broadcastSkill();             /* новая функция мозга -> нейронам    */
  }
}
void rpcSetVoice(int on) { voiceOn = (on != 0); }
void rpcSetHzcfg(String cfg) { if (cfg.length()) hzcfgApply(cfg.c_str()); }
void rpcSpeakTone(String cmd) {
  if (cmd == String("1")) voiceSay(genHz, 4);
  else { int hz = cmd.toInt(); if (hz > 50) voiceSay((uint16_t)hz, 3); }
}
void rpcTeachScore(int reward) { netTeach(reward >= 0 ? 1 : -1); }

/* v2.14: РЕЧЬ МОЗГА НА D8 (say_wave). Python разбирает WAV облака на
 * огибающую «частота:длительность;» — строки кадров «hz:ms;» — и шлёт сюда.
 * Проигрываем через существующий неблокирующий движок мелодий mel[]
 * (melTick в loop): каждый кадр = нота hz на ms, пауза = hz 0.
 * Речь мозга перебивает и мелодию слова, и мотивационные посылки.       */
String rpcSayWave(String frames) {
  if (!voiceOn) return String("voice_off");
  int16_t hz[MEL_MAX];
  uint16_t ms[MEL_MAX];
  uint8_t n = 0;
  int p = 0;
  int L = frames.length();
  while (p < L && n < MEL_MAX) {
    int colon = frames.indexOf(':', p);
    if (colon < 0) break;
    int semi = frames.indexOf(';', colon);
    if (semi < 0) semi = L;
    long f = frames.substring(p, colon).toInt();
    long d = frames.substring(colon + 1, semi).toInt();
    p = semi + 1;
    if (d <= 0) continue;
    if (f < 0) f = 0;
    if (f > 1200) f = 1200;
    if (d > 400) d = 400;
    hz[n] = (int16_t)f;
    ms[n] = (uint16_t)d;
    n++;
  }
  if (!n) return String("empty");
  voxSteps = 0;                       /* речь важнее «мотивации» и слова  */
  melIdx = 0;
  melLen = n;
  melTone = true;
  tMel = millis();
  for (uint8_t i = 0; i < n; i++) { mel[i].hz = (uint16_t)hz[i]; mel[i].ms = ms[i]; }
  if (mel[0].hz) toneHz = mel[0].hz;
  nextToneEdgeUs = micros();
  voiceWave++;                        /* статистика: сколько «речей»      */
  return String("ok:") + n;
}

/* v2.14: пульс моста — Python сам проверяет, жив ли скетч (когда on_state
 * молчат). Отвечаем мгновенно: аптайм в секундах.                       */
String rpcPing() { return String(millis() / 1000UL); }

/* v2.67: "гц,сила%" — общий ритм платформы (см. syncHz). Мгновенно. */
void rpcSyncHz(String v) {
  int c = v.indexOf(',');
  long hz = (c >= 0 ? v.substring(0, c) : v).toInt();
  long k = c >= 0 ? v.substring(c + 1).toInt() : 30;
  if (hz < 0) hz = 0;
  if (hz > 4000) hz = 4000;
  if (k < 0) k = 0;
  if (k > 60) k = 60;
  syncHz = (uint16_t)hz;
  syncK = (uint8_t)k;
  syncTs = millis();
}

/* v2.22: фраза мозга -> БУФЕР СЛОВ на D6. Python по-прежнему шлёт номера
 * букв через запятую ("4,1,33,0,15", 0 = пробел/знак; main.py не менялся).
 * Скетч декодирует их в ТЕКСТОВЫЙ буфер: 1..33 -> буква RU33, 0 -> пробел —
 * получается буфер, в котором СЛОВА. На D6 (d6Tick в loop) уходят БАЙТЫ
 * этого буфера, а не номера. Обработчик мгновенный — только заполняет
 * буфер.                                                               */
void rpcD6Seq(String seq) {
  char txt[D6_TXT_MAX + 1];
  uint16_t n = 0;
  long v = 0;
  bool have = false;
  for (unsigned i = 0; i <= seq.length(); i++) {
    char c = (i < seq.length()) ? seq.charAt(i) : ',';  // хвост — разделитель
    if (c >= '0' && c <= '9') {
      v = v * 10 + (c - '0');
      if (v > 99) v = 99;
      have = true;
    } else if (have) {
      uint8_t num = (uint8_t)constrain(v, 0, 33);
      if (num == 0) {                    // пробел/знак -> разделитель слов
        if (n && n < D6_TXT_MAX && txt[n - 1] != ' ') txt[n++] = ' ';
      } else if (n + 2 <= D6_TXT_MAX) {  // буква 1..33 -> 2 байта UTF-8
        txt[n++] = RU33[num - 1][0];
        txt[n++] = RU33[num - 1][1];
      }
      v = 0; have = false;
    }
    if (c != ',' && (c < '0' || c > '9')) break;
  }
  while (n && txt[n - 1] == ' ') n--;    // хвостовые пробелы — долой
  txt[n] = 0;
  if (n) d6PutText(txt);                 // начать немедленно
}

/* v2.46: знаковая частота на D6: "-37" / "120" -> кадр после текста. */
void rpcParticleCfg(String v) {
  /* формат: "grav:1,muon:0,phot:1,gen:800,cpu:1,min:100,max:4.0" */
  partGrav = v.indexOf("grav:1") >= 0;
  partMuon = v.indexOf("muon:1") >= 0;
  partPhot = v.indexOf("phot:1") >= 0;
  int g = v.indexOf("gen:");
  if (g >= 0) genFreqOverride = (uint16_t)v.substring(g + 4).toInt();
  cpuFreqLink = v.indexOf("cpu:1") >= 0;
  int mn = v.indexOf("min:");
  if (mn >= 0) freqBandMinMhz = v.substring(mn + 4).toFloat();
  int mx = v.indexOf("max:");
  if (mx >= 0) freqBandMaxGhz = v.substring(mx + 4).toFloat();
  if (genFreqOverride > 0 && genFreqOverride <= GEN_MAX_HZ) genHz = genFreqOverride;
}

void rpcD6Freq(String v) {
  long x = v.toInt();
  bool neg = x < 0;
  if (neg) x = -x;
  if (x > 65535L) x = 65535L;
  d6Frame[0] = neg ? 0xFF : 0xFE;
  d6Frame[1] = (uint8_t)((x >> 8) & 0xFF);
  d6Frame[2] = (uint8_t)(x & 0xFF);
  d6FramePend = true;                   // играет d6Tick после текста
}

/* v2.48: "off:neg:last:hex" — кусок кадра 16x12 (hex, 2 знака на точку). */
void rpcD6Img(String v) {
  int a = v.indexOf(':'), b = v.indexOf(':', a + 1), c = v.indexOf(':', b + 1);
  if (a < 0 || b < 0 || c < 0) return;
  int off = v.substring(0, a).toInt();
  bool neg = v.substring(a + 1, b).toInt() != 0;
  bool last = v.substring(b + 1, c).toInt() != 0;
  String hx = v.substring(c + 1);
  for (unsigned i = 0; i + 1 < hx.length(); i += 2) {
    int p = off + (int)(i / 2);
    if (p < 0 || p >= D6_IMG_N) break;
    char t[3] = {hx[i], hx[i + 1], 0};
    d6ImgIn[p] = (uint8_t)strtoul(t, nullptr, 16);
  }
  if (last) { d6ImgInNeg = neg; d6ImgRdy = true; }
}

/* v2.50/v2.51: "neg:hex[:f0,f1,...,f23]" — чистый кадр 32x24 для D4 (формат
 * как у d6pure) + необязательный профиль знаковых частот по строкам (Гц,
 * -2000..2000), который считает тензорная сеть платы. */
void rpcD4Pure(String v) {
  int a = v.indexOf(':');
  if (a < 0) return;
  int b = v.indexOf(':', a + 1);
  String hx = (b < 0) ? v.substring(a + 1) : v.substring(a + 1, b);
  if (hx.length() < D6P_N / 4) return;
  for (unsigned i = 0; i < D6P_N / 4; i++) {
    char c = hx[i];
    uint8_t n = (c >= 'a') ? (uint8_t)(c - 'a' + 10) : (uint8_t)(c - '0');
    for (uint8_t k = 0; k < 4; k++) d4fIn[i * 4 + k] = (n >> (3 - k)) & 1;
  }
  d4fProfOn = false;
  if (b > 0) {
    String pf = v.substring(b + 1);
    int pos = 0, r = 0;
    while (r < D6P_H && pos <= (int)pf.length()) {
      int c = pf.indexOf(',', pos);
      String one = (c < 0) ? pf.substring(pos) : pf.substring(pos, c);
      long x = one.toInt();
      if (x > D4F_MAX_HZ) x = D4F_MAX_HZ;
      if (x < -D4F_MAX_HZ) x = -D4F_MAX_HZ;
      d4fProf[r++] = (int16_t)x;
      if (c < 0) break;
      pos = c + 1;
    }
    d4fProfOn = (r == D6P_H);
  }
  d4fRdy = true;
}

/* v2.49: "neg:hex" — чистый кадр 32x24, 4 точки на hex-знак (старший бит
 * первым). hex = 192 знака. */
void rpcD6Pure(String v) {
  int a = v.indexOf(':');
  if (a < 0) return;
  bool neg = v.substring(0, a).toInt() != 0;
  String hx = v.substring(a + 1);
  if (hx.length() < D6P_N / 4) return;
  for (unsigned i = 0; i < D6P_N / 4; i++) {
    char c = hx[i];
    uint8_t n = (c >= 'a') ? (uint8_t)(c - 'a' + 10) : (uint8_t)(c - '0');
    for (uint8_t k = 0; k < 4; k++) d6pIn[i * 4 + k] = (n >> (3 - k)) & 1;
  }
  d6pInNeg = neg; d6pRdy = true;
}

/* v2.48: полярность D4: "-1" / "0" / "1". */
void rpcD4Pol(String v) {
  long x = v.toInt();
  d4Pol = x < 0 ? -1 : (x > 0 ? 1 : 0);
}

void rpcRegister() {
  Bridge.provide_safe("chat_stim", rpcChatStim);
  Bridge.provide_safe("val_b_set", rpcValB);
  Bridge.provide_safe("cloud_buf_set", rpcCloudBuf);
  Bridge.provide_safe("skill_out_set", rpcSkillOut);
  Bridge.provide_safe("set_voice", rpcSetVoice);
  Bridge.provide_safe("set_hzcfg", rpcSetHzcfg);
  Bridge.provide_safe("speak_tone", rpcSpeakTone);
  Bridge.provide_safe("teach_score", rpcTeachScore);
  Bridge.provide_safe("teach_last", rpcTeachLast);     /* v2.6: точечное обучение */
  Bridge.provide_safe("teach_shape", rpcTeachShape);   /* v2.6: маска наград  */
  Bridge.provide_safe("say_wave", rpcSayWave);         /* v2.14: речь на D8   */
  Bridge.provide_safe("d6seq", rpcD6Seq);              /* v2.22: буфер слов мозга на D6 */
  Bridge.provide_safe("d4pure", rpcD4Pure);             /* v2.50: чистый кадр на D4 (такт = частота генератора) */
  Bridge.provide_safe("d6pure", rpcD6Pure);             /* v2.49: чистый кадр на D6 (без PWM и байтов) */
  Bridge.provide_safe("d6img", rpcD6Img);               /* v2.48: кадр камеры растром на D6 */
  Bridge.provide_safe("d4pol", rpcD4Pol);               /* v2.48: полярность меандра D4 (знак частоты) */
  Bridge.provide_safe("d6freq", rpcD6Freq);
  Bridge.provide_safe("particle_cfg", rpcParticleCfg);   /* v2.92: конфиг частиц и частоты */            /* v2.46: знаковый кадр частоты на D6 */
  Bridge.provide_safe("word_push", rpcWordPush);       /* v2.27: слово из большого словаря */
  Bridge.provide_safe("word_q", rpcWordQ);             /* v2.34: очередь слов (память платы) */
  Bridge.provide_safe("neuro_assign", rpcNeuroAssign); /* v2.28: назначение номеров нейронам */
  Bridge.provide_safe("neuro_assign_poll", rpcNeuroAssignPoll); /* v2.33: прогресс назначения */
  Bridge.provide_safe("neuro_reset", rpcNeuroReset);   /* v2.29: сброс номеров нейронов */
  /* v2.94.1: кадр камеры отдаём из ПОТОКА МОСТА (provide, не provide_safe):
   * раньше запрос ждал конца прохода loop() и при занятом loop (I2C
   * нейронов, шум A4) не успевал за таймаут — «cam_frame_info не ответил» */
  Bridge.provide("cam_frame_info", rpcCamFrameInfo);      /* v2.30: кадр UART-камеры */
  Bridge.provide("cam_chunk", rpcCamChunk);               /* v2.30: кадр кусками (b64) */
  Bridge.provide_safe("cam_vis", rpcCamVis);              /* v2.88: зрение камеры (JSON) */
  Bridge.provide_safe("cam_vote", rpcCamVote);            /* v2.88: камера голосует за фразы */
  Bridge.provide_safe("cam_vote_res", rpcCamVoteRes);     /* v2.88: голос камеры */
  Bridge.provide_safe("cam_say", rpcCamSay);              /* v2.88: фраза мозга -> камере */
  /* v2.94.4: VR3 целиком в потоке моста (не ждёт loop): приём — кольцо из
   * прерывания (один писатель, один читатель), разбор — в vr_read */
  Bridge.provide("vr_read", rpcVrRead);                   /* v2.94: голосовой модуль VR3 */
  Bridge.provide("vr_enable", rpcVrEnable);               /* v2.94.3: включается из Python */
  Bridge.provide("vr_send", rpcVrSend);
  Bridge.provide_safe("ping", rpcPing);                /* v2.14: пульс моста  */
  Bridge.provide_safe("sync_hz", rpcSyncHz);           /* v2.67: общий ритм платформы */
  Bridge.provide("diag", rpcDiag);                     /* v2.68: из потока моста — работает, даже если loop() завис */
}
void bridgeSync() {
  /* Периодический опрос не нужен: события уходят сами (on_state — из
   * analyzeAndPrint, буквы/слова/фразы — из letterTick/wordCommit/
   * sentenceDone), команды Python приходят RPC-методами выше.        */
}
#elif USE_BRIDGE
void bridgeSync() {
  if (millis() - tBridge < BRIDGE_MS) return;
  tBridge = millis();
  char tmp[VAL_B_SIZE];
  if (Bridge.get("val_b", tmp, VAL_B_SIZE - 1) > 0) {
    strlcpy(val_b, tmp, VAL_B_SIZE); sanitize(val_b);
  }
  if (Bridge.get("chat_out", tmp, CHAT_OUT_SIZE - 1) > 0) {
    if (strlen(tmp)) {                   // новое сообщение из чата -> нейронам
      strlcpy(chat_out, tmp, CHAT_OUT_SIZE); sanitize(chat_out);
      broadcastStim(chat_out);
      Bridge.put("chat_out", "");        // подтверждаем приём
    }
  }
  if (Bridge.get("cloud_buf", tmp, CLOUD_BUF_SIZE - 1) > 0) {
    tmp[CLOUD_BUF_SIZE - 1] = 0;
    if (strlen(tmp) && strcmp(tmp, cloud_buf) != 0) {
      strlcpy(cloud_buf, tmp, CLOUD_BUF_SIZE); sanitize(cloud_buf);
      broadcastBuf();                    // сводка облака -> нейронам
    }
  }
  if (Bridge.get("skill_out", tmp, SKILL_OUT_SIZE - 1) > 0) {
    tmp[SKILL_OUT_SIZE - 1] = 0;
    if (strlen(tmp) && strcmp(tmp, skill_out) != 0) {
      strlcpy(skill_out, tmp, SKILL_OUT_SIZE); sanitize(skill_out);
      broadcastSkill();                  // новая функция мозга -> нейронам
    }
  }
  /* ДИНАМИК (v1.9): "speak"="1" — озвучить мысль/реплику фразой из 4 посылок;
   * "speak"="<hz>" — одиночная фраза с базовой частотой; "voice"="0/1" —
   * вкл/выкл голоса (Cloud Studio, панель «Настройки»).                 */
  if (Bridge.get("voice", tmp, 8) > 0) {
    if (tmp[0] == '0') voiceOn = false;
    else if (tmp[0] == '1') voiceOn = true;
  }
  /* НАСТРОЙКИ СКЕТЧА (v2.2): "hzcfg"="min,max,cam,mic,txt,spk" из Studio */
  if (Bridge.get("hzcfg", tmp, 40) > 0) {
    tmp[39] = 0;
    if (strlen(tmp)) {
      hzcfgApply(tmp);
      Bridge.put("hzcfg", "");        // подтверждаем приём
    }
  }
  if (Bridge.get("speak", tmp, 16) > 0) {
    tmp[15] = 0;
    if (strlen(tmp)) {
      if (tmp[0] == '1' && !tmp[1]) voiceSay(genHz, 4);
      else { int hz = atoi(tmp); if (hz > 50) voiceSay((uint16_t)hz, 3); }
      Bridge.put("speak", "");           // подтверждаем приём
    }
  }
  /* v2.3: LLM-УЧИТЕЛЬ: "teach"="+1"/"-1" — подкрепить/ослабить решения
   * завершённой фразы. Учитель НЕ выбирает букву — выбор всегда за сетью. */
  if (Bridge.get("teach", tmp, 8) > 0) {
    tmp[7] = 0;
    if (strlen(tmp)) {
      if (tmp[0] == '+') netTeach(1);
      else if (tmp[0] == '-') netTeach(-1);
      Bridge.put("teach", "");             // подтверждаем приём
    }
  }
  /* v2.3: частота и номер буквы — короткие ключи моста: их видно даже если
   * длинные буферы не проходят (так «информация о частоте» не теряется) */
  char kb[12];
  snprintf(kb, sizeof(kb), "%u", (unsigned)genHz);
  Bridge.put("gen_hz", kb);
  snprintf(kb, sizeof(kb), "%u", (unsigned)curLetterNum);
  Bridge.put("ltr", kb);
  Bridge.put("total_val_c", total_val_c);
  Bridge.put("val_c", val_c);
}
#else
/* Запасной протокол (без Arduino_Bridge), hex-кодирование:
 *   GETK <key>            -> VALK <key> <hex> | VALK <key> -
 *   PUTK <key> <hex>      -> OKK              (val_b / chat_out / cloud_buf / skill_out)
 *   PING                  -> PONG <millis>                                   */
void hexDecode(const char *hex, char *out, uint16_t maxOut) {
  uint16_t o = 0;
  for (uint16_t i = 0; hex[i] && hex[i + 1] && o < maxOut - 1; i += 2) {
    char b[3] = {hex[i], hex[i + 1], 0};
    out[o++] = (char)strtol(b, nullptr, 16);
  }
  out[o] = 0;
}
void serialProto() {
  static char line[1100]; static uint16_t ln = 0;
  while (HUB_OUT.available()) {
    char c = (char)HUB_OUT.read();
    if (c == '\n') { line[ln] = 0; break; }
    if (c != '\r' && ln < sizeof(line) - 1) line[ln++] = c;
    return;                              // строка ещё не собрана
  }
  if (ln == 0 || line[ln] != 0) return;
  ln = 0;

  if (!strncmp(line, "PING", 4)) { HUB_OUT.print("PONG "); HUB_OUT.println(millis()); return; }
  if (!strncmp(line, "GETK ", 5)) {
    const char *key = line + 5;
    if (!strcmp(key, "gen_hz") || !strcmp(key, "ltr")) {   // v2.3: короткие ключи
      HUB_OUT.print("VALK "); HUB_OUT.print(key); HUB_OUT.print(' ');
      if (!strcmp(key, "gen_hz")) HUB_OUT.print((unsigned)genHz);
      else HUB_OUT.print((unsigned)curLetterNum);
      HUB_OUT.println();
      return;
    }
    const char *src = (!strcmp(key, "total_val_c")) ? total_val_c
                    : (!strcmp(key, "val_c"))       ? val_c
                    : (!strcmp(key, "say"))         ? sayBuf : "";
    if (!src[0] && !strcmp(key, "total_val_c")) src = "";
    HUB_OUT.print("VALK "); HUB_OUT.print(key); HUB_OUT.print(' ');
    for (const char *p = src; *p; p++) HUB_OUT.print((uint8_t)*p < 16 ? "0" : ""), HUB_OUT.print((uint8_t)*p, HEX);
    if (!src[0]) HUB_OUT.print("-");
    HUB_OUT.println();
    return;
  }
  if (!strncmp(line, "PUTK ", 5)) {
    char key[24]; uint16_t k = 0; const char *p = line + 5;
    while (*p && *p != ' ' && k < 23) key[k++] = *p++;
    key[k] = 0; if (*p == ' ') p++;
    char dec[VAL_B_SIZE]; hexDecode(p, dec, sizeof(dec));
    if      (!strcmp(key, "val_b"))    { strlcpy(val_b, dec, VAL_B_SIZE);    sanitize(val_b); }
    else if (!strcmp(key, "chat_out")) { strlcpy(chat_out, dec, CHAT_OUT_SIZE); sanitize(chat_out); broadcastStim(chat_out); }
    else if (!strcmp(key, "cloud_buf")) {
      if (strlen(dec) && strcmp(dec, cloud_buf) != 0) {
        strlcpy(cloud_buf, dec, CLOUD_BUF_SIZE); sanitize(cloud_buf);
        broadcastBuf();                // сводка облака -> нейронам
      }
    }
    else if (!strcmp(key, "skill_out")) {
      if (strlen(dec) && strcmp(dec, skill_out) != 0) {
        strlcpy(skill_out, dec, SKILL_OUT_SIZE); sanitize(skill_out);
        broadcastSkill();              // новая функция мозга -> нейронам
      }
    }
    else if (!strcmp(key, "voice")) {  // v1.9: вкл/выкл голоса
      if (dec[0] == '0') voiceOn = false;
      else if (dec[0] == '1') voiceOn = true;
    }
    else if (!strcmp(key, "speak")) {  // v1.9: озвучить мысль/реплику
      if (dec[0] == '1' && !dec[1]) voiceSay(genHz, 4);
      else { int hz = atoi(dec); if (hz > 50) voiceSay((uint16_t)hz, 3); }
    }
    else if (!strcmp(key, "hzcfg")) {  // v2.2: частоты шины из Studio
      if (strlen(dec)) hzcfgApply(dec);
    }
    else if (!strcmp(key, "teach")) {  // v2.3: награда учителя (+1/-1)
      if (dec[0] == '+') netTeach(1);
      else if (dec[0] == '-') netTeach(-1);
    }
    HUB_OUT.println("OKK");
  }
}
void bridgeSync() {
  if (millis() - tBridge < BRIDGE_MS) return;
  tBridge = millis();
  serialProto();
}
#endif

/* ----------------------------- МИКРОФОН ---------------------------------- */
/* Считаем переходы уровня на D12/D13 (модули звука с цифровым выходом DO;
 * полярность не важна — считаем оба фронта). Каждые MIC_WIN_MS обновляем
 * сглаженную громкость micLevel 0..100 — она поднимает частоту генератора.  */
void micTick() {
  for (uint8_t k = 0; k < MIC_PINS_N; k++) {
    bool s = digitalRead(MIC_PIN[k]) == HIGH;
    if (s != micLast[k]) { micLast[k] = s; if (micHits < 250) micHits++; }
  }
  if (millis() - tMic < MIC_WIN_MS) return;
  tMic = millis();
  int inst = (int)micHits * 100 / MIC_HITS_MAX; if (inst > 100) inst = 100;
  micHits = 0;
  micLevel = (uint8_t)(((uint16_t)micLevel * 3 + (uint16_t)inst) / 4);  // EMA
  /* анти-заводка голоса (v1.9): следим за перегрузом микрофона */
  if (micLevel > MIC_HOT_LEVEL) {
    if (!micHotSince) micHotSince = millis();
  } else {
    micHotSince = 0;
  }
}

/* ----------------------------- SETUP / LOOP ------------------------------ */
/* v2.68: ДИАГНОСТИКА ЗАВИСАНИЙ. bootStage — на каком шаге setup() скетч,
 * loopStage — какую функцию loop() он выполняет; loopCount — проходы loop().
 * Метод diag отвечает из ПОТОКА МОСТА (provide, не provide_safe), то есть
 * даже когда loop() завис: приложение видит, где именно. */
volatile uint8_t  bootStage = 0;
volatile uint8_t  loopStage = 0;
volatile uint32_t loopCount = 0;
String rpcDiag() {
  return String((int)bootStage) + "," + String((int)loopStage) + "," +
         String((unsigned long)loopCount) + "," + String(millis() / 1000UL);
}
static void bootAt(uint8_t st) {
  bootStage = st;
#if USE_RB
  Bridge.notify("on_boot", (int)st);
#endif
}

void setup() {
#if USE_RB
  /* v2.68: МОСТ — ПЕРВЫМ, до шины нейронов, камеры и EEPROM: если что-то
   * из них зависнет, приложение всё равно увидит скетч и шаг зависания */
  Bridge.begin();
  Bridge.notify("$/setMaxMsgSize", 8192);  /* запас на длинные фразы */
  HubOut.mon = Monitor.begin();            /* панель Monitor открыта? */
  rpcRegister();
  bootAt(1);
#else
  HUB_OUT.begin(115200);
#endif
  pinMode(GEN_PIN, OUTPUT);
  digitalWrite(GEN_PIN, LOW);
  pinMode(SPEAKER_PIN, OUTPUT);        // динамик (v1.9): мотивация говорить
  digitalWrite(SPEAKER_PIN, LOW);
  pinMode(NN_OUT_PIN, OUTPUT);         // v2.22: буфер слов (UTF-8 байты) на D6 (PWM)
  analogWrite(NN_OUT_PIN, 0);
  for (uint8_t k = 0; k < MIC_PINS_N; k++) pinMode(MIC_PIN[k], INPUT);
  /* v2.94.3: VR3 при старте НЕ трогаем (прерывание на D12 включает Python
   * командой vr_enable, когда мост уже жив) — иначе сбой прерывания мог
   * уронить скетч на старте, и мост молчал */
#if !LINK_SW_WIRE
  for (uint8_t b = 0; b < 4; b++) pinMode(MUX_PINS[b], OUTPUT);
#endif

  bootAt(2);                     // v2.68: шина нейронов
#if LINK_SW_WIRE
  NeuroBus.begin();
  NeuroBus.setClock(20000);      // v2.23: 20 кГц вместо 100 — длинные провода
                                 // до нейронов перестают терять биты
  i2cBusRecover();               // v2.23: разморозить шину после сброса платы
#else
  NeuroSer.begin(9600);
#endif

/* v2.30: приёмник камеры по UART — стартует всегда (кадры копятся, даже
 * если мозг их не спрашивает); при LINK_SW_WIRE 0 Serial1 может быть
 * занят нейронами — тогда эту секцию придётся убрать вместе с камерой */
  bootAt(3);                     // v2.68: приёмник камеры
#if defined(ARDUINO_ARCH_STM32)
  CAMRX.setRxBufferSize(2048);   // большой приёмный буфер: loop занят нейронами
#endif
  CAMRX.begin(CAMRX_BAUD);
  HUB_OUT.print("[CAM-UART] приёмник кадров готов: ");
  HUB_OUT.print(CAMRX_BAUD);
  HUB_OUT.println(" бод; TX ESP32-CAM (GPIO13) -> RX Serial1/D0, GND общий");

#if USE_RB
  HUB_OUT.println("[HUB] Arduino_RouterBridge: OK (RPC App Lab), мост поднят первым (v2.68)");
#elif USE_BRIDGE
  Bridge.begin();
  HUB_OUT.println("[HUB] Arduino_Bridge: OK");
#else
  HUB_OUT.println("[HUB] мостов нет: работаю по протоколу GETK/PUTK");
#endif
#if BUS_READY == 2
  HUB_OUT.println("[HUB] ВНИМАНИЕ: SoftwareWire не найден, использую аппаратный Wire (SDA/SCL)");
#endif
  HUB_OUT.println("[HUB] Мозг-12 v2.4-app (App Lab): шина D4 -> A0 нейронов; RPC RouterBridge");
  HUB_OUT.println("[HUB] Частота = покой + камера(val_b) + микрофон(D12/D13) + текст + спайки");
  HUB_OUT.println("[HUB] Динамик D8: мотивация говорить (голосовая петля, VOX= в total_val_c)");
  bootAt(4);                           // v2.68: EEPROM
  hzcfgLoad();                         // v2.2: настройки из Studio (EEPROM)
  if (genHz < cfgMinHz) genHz = cfgMinHz;
  if (genHz > cfgMaxHz) genHz = cfgMaxHz;
  HUB_OUT.print("[HUB] Частоты (Studio/EEPROM): min="); HUB_OUT.print(cfgMinHz);
  HUB_OUT.print(" max="); HUB_OUT.print(cfgMaxHz);
  HUB_OUT.print(" cam="); HUB_OUT.print(cfgCamSpan);
  HUB_OUT.print(" mic="); HUB_OUT.print(cfgMicSpan);
  HUB_OUT.print(" txt="); HUB_OUT.print(cfgTxtSpan);
  HUB_OUT.print(" spk="); HUB_OUT.println(cfgSpkSpan);
  /* v2.3: НЕЙРОСЕТЬ БУКВ — веса из EEPROM или приоры речи */
  if (!netLoad()) {
    netInitWeights();
    HUB_OUT.println("[HUB] Буквогенератор v2.3: веса инициализированы (приоры речи)");
  } else {
    HUB_OUT.println("[HUB] Буквогенератор v2.3: веса загружены из EEPROM");
  }
  netSave();
  /* v2.26: СЛОВОГЕНЕРАТОР — слова из словаря, веса слов в EEPROM */
  for (uint8_t i = 0; i < NEURONS; i++) idSeen[i] = -1;
  if (!wordsLoad()) {
    memset(wordW, 0, sizeof(wordW));
    memset(wordCtx, 0, sizeof(wordCtx));
    HUB_OUT.print("[HUB] Словогенератор v2.26: словарь ");
    HUB_OUT.print((unsigned)WD_N);
    HUB_OUT.println(" слов (веса с нуля, учитель подкрепляет)");
  } else {
    HUB_OUT.print("[HUB] Словогенератор v2.26: ");
    HUB_OUT.print((unsigned)WD_N);
    HUB_OUT.println(" слов, веса из EEPROM");
  }
  wordsSave();
  HUB_OUT.println("[HUB] Буквогенератор: 1..33 -> буквы + пробел/запятая/точка;");
  HUB_OUT.println("[HUB]   номер буквы -> тег частоты (нейроны слышат без правки кода);");
  HUB_OUT.println("[HUB]   слова -> STIM нейронам + мелодия D8; фразы -> SAY= (TTS/чат);");
  HUB_OUT.println("[HUB]   LLM-учитель: teach_score=±1, teach_last/teach_shape — точечно");
  strlcpy(val_c, "boot", VAL_C_SIZE);
  strlcpy(val_b, "no-video", VAL_B_SIZE);
  strlcpy(cloud_buf, "no-cloud", CLOUD_BUF_SIZE);
  strlcpy(skill_out, "no-skill", SKILL_OUT_SIZE);
  analyzeAndPrint(); tAnalyze = 0;
  nextEdgeUs = micros();
  bootAt(9);                           // v2.68: setup() завершён
}

void loop() {
  loopCount++;                       // v2.68: шаг loop() — для diag
  /* v2.93: приёмник камеры опрашиваем МЕЖДУ всеми этапами: на 460800 бод
   * аппаратный буфер Serial1 заполняется за ~1-2 мс, и любой медленный этап
   * (I2C нейронов, АЦП, RPC) раньше рвал кадры (bad растёт, ok стоит). */
  loopStage = 1;  d4fTick();           camUartTick();   // v2.50: кадр камеры на D4 (если есть)
  loopStage = 2;  freqTick();          camUartTick();   // 1. генератор: меандр genHz на D4 -> A0 всех нейронов
  loopStage = 3;  voiceTick();         camUartTick();   // 2. динамик (v1.9): голос мозга / мотивация говорить
  loopStage = 4;  micTick();           camUartTick();   // 3. микрофон (KY-037 на D10/D11)   // 3. микрофон: звук на D12/D13 -> micLevel
  loopStage = 5;  pollNext();          camUartTick();   // 4. опрос нейронов -> val_c
  loopStage = 6;  letterTick();        camUartTick();   // 5. буквогенератор (v2.3): нейросеть 1..33 -> буквы -> слова
  loopStage = 7;  d6Tick();            camUartTick();   // 5a. v2.22: проигрывание буфера слов на D6 (PWM)
  particleTick();          // v2.92: дискретные кванты частиц, если включены
  sampleCapNoise();        // v2.93: шум конденсатора (1 выборка / 4 мс)
  noiseAsStim();           // шум -> STIM нейронам + подъём genHz
  updateLearningScale();   // частота D6 + шум -> скорость весов
  loopStage = 8;  camUartTick();       // 5b. v2.30: приём кадров камеры по UART (ESP32-CAM)
  loopStage = 9;  neuroAssignTick();   camUartTick();   // 5c. v2.33: назначение нейронов — один шаг, БЕЗ delay()
  loopStage = 10; eePumpTick();        camUartTick();   // 5d. v2.67: веса в EEPROM — по 2 байта за проход
  loopStage = 11; bridgeSync();        camUartTick();   // 6. обмен с Linux-стороной (val_b, chat_out, teach, speak / total_val_c)
  loopStage = 12; analyzeAndPrint();   camUartTick();   // 7. анализ val_c (+val_b, звук) -> частота и total_val_c
  loopStage = 0;
  /* v2.94.5: ДАТЬ ПОТОКУ МОСТА ПРОЦЕССОР. loop() на Zephyr — обычный поток;
   * если он не спит, поток RouterBridge (приём вызовов от Linux) не получает
   * времени: от скетча уведомления уходят, а ВСЕ вызовы из Python (diag,
   * cam_frame_info, say_wave…) — «timed out». До v2.93 спать заставляли
   * 8 analogRead за проход (АЦП ждёт семафор); с v2.93 АЦП читается редко —
   * и мост задыхался. Теперь — сон 1 мс каждые 3 мс (кадры камеры копит
   * драйвер UART по прерыванию). */
  static uint32_t yieldMs = 0;
  if ((uint32_t)(millis() - yieldMs) >= 3) {
    yieldMs = millis();
    delay(1);
  }
}
